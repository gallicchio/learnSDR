options:
  parameters:
    author: Claude (Oct 2026), in the style of the learnSDR lessons
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson25b_GMSK_Pluto_to_RTL
    output_language: python
    title: GMSK from Pluto to RTL-SDR
  states: {}

blocks:
- name: bt
  id: variable
  parameters:
    comment: Gaussian BT product
    value: '0.3'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: h
  id: variable
  parameters:
    comment: modulation index (0.5 for MSK/GMSK)
    value: '0.5'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '49'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: samples per bit
    value: '16'
  states: {}
- name: ted_gain
  id: variable
  parameters:
    comment: |-
      measured S-curve slope of the Mueller & Muller TED
      on this demodulated GMSK signal (per sample)
    value: '0.06'
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '10'
  states: {}
- name: analog_agc_xx_16
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_18
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      FM demodulator: phase change per sample.
      Gain chosen so the output is +/-1 for the two tones.
      No carrier phase recovery needed - that is the
      beauty of FSK
    gain: sps/(math.pi*h)
  states: {}
- name: analog_random_source_x_10
  id: analog_random_source_x
  parameters:
    comment: random bytes
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_char_to_float_25
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_28
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_12
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      GMSK has constant envelope, so no
      peaks to worry about - just a safe level
    const: '0.5'
    type: complex
  states: {}
- name: dc_blocker_xx_19
  id: dc_blocker_xx
  parameters:
    comment: |-
      the frequency error between Pluto and RTL-SDR
      shows up as a DC offset after FM demodulation;
      this high-pass filter removes it (compare with
      the FLL in Lesson 17)
    length: '1024'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_binary_slicer_fb_24
  id: digital_binary_slicer_fb
  parameters:
    comment: '> 0 -> 1, < 0 -> 0'
  states: {}
- name: digital_gmsk_mod_11
  id: digital_gmsk_mod
  parameters:
    bt: bt
    comment: |-
      GNU Radio's GMSK modulator: unpack bits,
      Gaussian filter, FM with h = 0.5
      (Lesson 25a builds the same thing from parts)
    samples_per_symbol: sps
  states: {}
- name: digital_symbol_sync_xx_23
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      bit timing recovery (Lesson 18), float version,
      no matched filter bank needed
    damping: '1.0'
    loop_bw: '0.02'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: ted_gain
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: iio_pluto_sink_13
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(center_freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_7
  id: import
  parameters:
    imports: |-
      import math
      from gnuradio import gr
  states: {}
- name: low_pass_filter_17
  id: low_pass_filter
  parameters:
    comment: |-
      channel filter: about one bit-rate wide. An FM
      demodulator turns ALL the noise in its input into
      output noise, so cut the bandwidth down first
    cutoff_freq: samp_rate/sps
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/sps/2
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_27
  id: qtgui_const_sink_x
  parameters:
    label1: +/-1 if the timing is right
    name: '"Timing-recovered samples"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_22
  id: qtgui_eye_sink_x
  parameters:
    comment: the Gaussian filtering shows up as rounded transitions
    label1: demodulated GMSK
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_14
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    label1: GMSK
    name: '"Transmitted spectrum"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_20
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    label1: RTL-SDR
    name: '"Received spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_21
  id: qtgui_time_sink_x
  parameters:
    label1: before DC blocker (offset = frequency error)
    label2: after DC blocker
    name: '"FM demodulator output"'
    nconnections: '2'
    size: '2048'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_26
  id: qtgui_time_sink_x
  parameters:
    label1: bits
    name: '"Received bits"'
    size: '200'
    srate: samp_rate/sps
    type: float
  states: {}
- name: rtlsdr_source_15
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_16, '0', low_pass_filter_17, '0']
- [analog_quadrature_demod_cf_18, '0', dc_blocker_xx_19, '0']
- [analog_quadrature_demod_cf_18, '0', qtgui_time_sink_x_21, '0']
- [analog_random_source_x_10, '0', digital_gmsk_mod_11, '0']
- [blocks_char_to_float_25, '0', qtgui_time_sink_x_26, '0']
- [blocks_float_to_complex_28, '0', qtgui_const_sink_x_27, '0']
- [blocks_multiply_const_vxx_12, '0', iio_pluto_sink_13, '0']
- [blocks_multiply_const_vxx_12, '0', qtgui_freq_sink_x_14, '0']
- [dc_blocker_xx_19, '0', digital_symbol_sync_xx_23, '0']
- [dc_blocker_xx_19, '0', qtgui_eye_sink_x_22, '0']
- [dc_blocker_xx_19, '0', qtgui_time_sink_x_21, '1']
- [digital_binary_slicer_fb_24, '0', blocks_char_to_float_25, '0']
- [digital_gmsk_mod_11, '0', blocks_multiply_const_vxx_12, '0']
- [digital_symbol_sync_xx_23, '0', blocks_float_to_complex_28, '0']
- [digital_symbol_sync_xx_23, '0', digital_binary_slicer_fb_24, '0']
- [low_pass_filter_17, '0', analog_quadrature_demod_cf_18, '0']
- [rtlsdr_source_15, '0', analog_agc_xx_16, '0']
- [rtlsdr_source_15, '0', qtgui_freq_sink_x_20, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
