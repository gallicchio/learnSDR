options:
  parameters:
    author: Claude (Oct 2026), in the style of the learnSDR lessons
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson36_Error_Correction
    output_language: python
    title: 'Error-correcting codes: a convolutional code and the Viterbi decoder (simulation)'
  states: {}

blocks:
- name: dec
  id: variable_cc_decoder_def
  parameters:
    comment: |-
      Viterbi decoder: finds the bit sequence whose
      encoding is closest to what was received
    framebits: frame_bits
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79, 109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: enc
  id: variable_cc_encoder_def
  parameters:
    comment: |-
      rate-1/2, constraint-length-7 convolutional code:
      every input bit produces 2 output bits that depend
      on it and the 6 bits before it (polynomials 79, 109 =
      the NASA/Voyager "K=7" code, also in Wi-Fi and LTE)
    framebits: frame_bits
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79, 109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: frame_bits
  id: variable
  parameters:
    comment: bits per coded frame
    value: '2048'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    comment: |-
      noise RMS per transmitted +/-1 symbol (real noise, N0 = 2 sigma^2):
      Eb/N0 (dB) = -20*log10(noise_voltage) - 3.  0.5 -> 3 dB, 0.35 -> 6 dB
    start: '0'
    step: '0.02'
    stop: '2'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: analog_noise_source_x_12
  id: analog_noise_source_x
  parameters:
    amp: noise_voltage
    noise_type: analog.GR_GAUSSIAN
    seed: '1'
    type: float
  states: {}
- name: analog_noise_source_x_23
  id: analog_noise_source_x
  parameters:
    amp: noise_voltage
    noise_type: analog.GR_GAUSSIAN
    seed: '2'
    type: float
  states: {}
- name: analog_random_source_x_7
  id: analog_random_source_x
  parameters:
    comment: random bits (one per byte)
    max: '2'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_const_vxx_10
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_21
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_xx_13
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_24
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_20
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_9
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_11
  id: blocks_multiply_const_vxx
  parameters:
    comment: bit -> +/-1 (BPSK)
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_22
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      bit -> +/-1, then scaled by 1/sqrt(2): the coded
      branch sends twice as many symbols, so each gets
      half the energy. Same energy per DATA bit as above
    const: 2/math.sqrt(2)
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_15
  id: blocks_pack_k_bits_bb
  parameters:
    comment: the BER block wants packed bytes
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_16
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_26
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_28
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle2_8
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_binary_slicer_fb_14
  id: digital_binary_slicer_fb
  parameters:
    comment: hard decision
  states: {}
- name: fec_ber_bf_17
  id: fec_ber_bf
  parameters:
    comment: |-
      compares the two streams bit by bit
      and outputs log10(bit error rate)
    test_mode: 'False'
  states: {}
- name: fec_ber_bf_27
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: fec_extended_decoder_25
  id: fec_extended_decoder
  parameters:
    comment: |-
      takes the noisy +/-1 values ("soft decisions"),
      not sliced bits: a received 0.1 counts less than a 0.9
    decoder_list: dec
    puncpat: '"11"'
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_19
  id: fec_extended_encoder
  parameters:
    comment: 2 coded bits out per bit in
    encoder_list: enc
    puncpat: '"11"'
    threadtype: capillary
  states: {}
- name: import_3
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_number_sink_18
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: log10(BER)
    max: '0'
    min: '-7'
    name: '"Uncoded BPSK"'
    type: float
  states: {}
- name: qtgui_number_sink_29
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: log10(BER)
    max: '0'
    min: '-7'
    name: '"Rate-1/2 convolutional code + Viterbi"'
    type: float
  states: {}
- name: qtgui_time_sink_x_30
  id: qtgui_time_sink_x
  parameters:
    label1: +/-0.71 plus noise
    name: '"Noisy received symbols (coded branch)"'
    size: '200'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_noise_source_x_12, '0', blocks_add_xx_13, '1']
- [analog_noise_source_x_23, '0', blocks_add_xx_24, '1']
- [analog_random_source_x_7, '0', blocks_throttle2_8, '0']
- [blocks_add_const_vxx_10, '0', blocks_multiply_const_vxx_11, '0']
- [blocks_add_const_vxx_21, '0', blocks_multiply_const_vxx_22, '0']
- [blocks_add_xx_13, '0', digital_binary_slicer_fb_14, '0']
- [blocks_add_xx_24, '0', fec_extended_decoder_25, '0']
- [blocks_add_xx_24, '0', qtgui_time_sink_x_30, '0']
- [blocks_char_to_float_20, '0', blocks_add_const_vxx_21, '0']
- [blocks_char_to_float_9, '0', blocks_add_const_vxx_10, '0']
- [blocks_multiply_const_vxx_11, '0', blocks_add_xx_13, '0']
- [blocks_multiply_const_vxx_22, '0', blocks_add_xx_24, '0']
- [blocks_pack_k_bits_bb_15, '0', fec_ber_bf_17, '0']
- [blocks_pack_k_bits_bb_16, '0', fec_ber_bf_17, '1']
- [blocks_pack_k_bits_bb_26, '0', fec_ber_bf_27, '1']
- [blocks_pack_k_bits_bb_28, '0', fec_ber_bf_27, '0']
- [blocks_throttle2_8, '0', blocks_char_to_float_9, '0']
- [blocks_throttle2_8, '0', blocks_pack_k_bits_bb_15, '0']
- [blocks_throttle2_8, '0', blocks_pack_k_bits_bb_28, '0']
- [blocks_throttle2_8, '0', fec_extended_encoder_19, '0']
- [digital_binary_slicer_fb_14, '0', blocks_pack_k_bits_bb_16, '0']
- [fec_ber_bf_17, '0', qtgui_number_sink_18, '0']
- [fec_ber_bf_27, '0', qtgui_number_sink_29, '0']
- [fec_extended_decoder_25, '0', blocks_pack_k_bits_bb_26, '0']
- [fec_extended_encoder_19, '0', blocks_char_to_float_20, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
