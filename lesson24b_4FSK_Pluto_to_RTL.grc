options:
  parameters:
    author: Claude (Oct 2026), in the style of the learnSDR lessons
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson24b_4FSK_Pluto_to_RTL
    output_language: python
    title: 4-FSK (as used by FLEX pagers and DMR) from Pluto to RTL-SDR
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: deviation
  id: variable
  parameters:
    comment: the four tones are at -3, -1, +1, +3 times this (Hz)
    value: 10e3
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '49'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    comment: 10 ksymbol/s = 20 kbit/s
    value: '100'
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '10'
  states: {}
- name: analog_agc_xx_18
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_20
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      FM demodulator, scaled so the four tones
      come out as -3, -1, +1, +3
    gain: samp_rate/(2*math.pi*deviation)
  states: {}
- name: analog_random_source_x_8
  id: analog_random_source_x
  parameters:
    comment: 'random 2-bit symbols: 0, 1, 2, 3'
    max: '4'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_12
  id: blocks_multiply_const_vxx
  parameters:
    comment: level -> frequency
    const: deviation
    type: float
  states: {}
- name: blocks_repeat_10
  id: blocks_repeat
  parameters:
    interp: samples_per_symbol
    type: float
  states: {}
- name: blocks_vco_c_13
  id: blocks_vco_c
  parameters:
    amplitude: '0.5'
    comment: frequency -> complex tone (Lesson 24)
    samp_rate: samp_rate
    sensitivity: 2*math.pi
  states: {}
- name: dc_blocker_xx_21
  id: dc_blocker_xx
  parameters:
    comment: |-
      removes the Pluto/RTL-SDR frequency error
      (a DC offset after FM demodulation)
    length: '4096'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_chunks_to_symbols_xx_9
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: |-
      2 bits -> one of four levels (Gray-ish: FLEX uses
      -3,-1,+1,+3 for 00,01,11,10)
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-3, -1, 1, 3]'
  states: {}
- name: iio_pluto_sink_14
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(center_freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_5
  id: import
  parameters:
    imports: |-
      import math
      from gnuradio import gr
  states: {}
- name: low_pass_filter_11
  id: low_pass_filter
  parameters:
    comment: round off the corners a little (Lesson 24)
    cutoff_freq: samp_rate/samples_per_symbol
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: samp_rate/samples_per_symbol
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_19
  id: low_pass_filter
  parameters:
    comment: 'channel filter: wide enough for the outer tones'
    cutoff_freq: 4*deviation
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2*deviation
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_eye_sink_x_24
  id: qtgui_eye_sink_x
  parameters:
    comment: 'three "eyes" stacked: the slicer needs thresholds at -2, 0, +2'
    label1: 4-FSK eye
    samp_per_symbol: samples_per_symbol
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_freq_sink_x_15
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    label1: 4-FSK
    name: '"Transmitted: four tones"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_22
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    label1: RTL-SDR
    name: '"Received spectrum"'
    type: complex
  states: {}
- name: qtgui_histogram_sink_x_25
  id: qtgui_histogram_sink_x
  parameters:
    bins: '200'
    comment: four peaks = four frequencies
    label1: four peaks
    name: '"Histogram of the demodulated signal"'
    size: '8192'
    type: float
    xmax: '5'
    xmin: '-5'
  states: {}
- name: qtgui_time_sink_x_16
  id: qtgui_time_sink_x
  parameters:
    label1: instantaneous frequency (Hz)
    name: '"Transmitted frequency"'
    size: '2048'
    srate: samp_rate
    type: float
    ymax: 4*deviation
    ymin: '-4*deviation'
  states: {}
- name: qtgui_time_sink_x_23
  id: qtgui_time_sink_x
  parameters:
    label1: frequency / deviation
    name: '"Demodulated: four levels"'
    size: '2048'
    srate: samp_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: rtlsdr_source_17
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_18, '0', low_pass_filter_19, '0']
- [analog_quadrature_demod_cf_20, '0', dc_blocker_xx_21, '0']
- [analog_random_source_x_8, '0', digital_chunks_to_symbols_xx_9, '0']
- [blocks_multiply_const_vxx_12, '0', blocks_vco_c_13, '0']
- [blocks_multiply_const_vxx_12, '0', qtgui_time_sink_x_16, '0']
- [blocks_repeat_10, '0', low_pass_filter_11, '0']
- [blocks_vco_c_13, '0', iio_pluto_sink_14, '0']
- [blocks_vco_c_13, '0', qtgui_freq_sink_x_15, '0']
- [dc_blocker_xx_21, '0', qtgui_eye_sink_x_24, '0']
- [dc_blocker_xx_21, '0', qtgui_histogram_sink_x_25, '0']
- [dc_blocker_xx_21, '0', qtgui_time_sink_x_23, '0']
- [digital_chunks_to_symbols_xx_9, '0', blocks_repeat_10, '0']
- [low_pass_filter_11, '0', blocks_multiply_const_vxx_12, '0']
- [low_pass_filter_19, '0', analog_quadrature_demod_cf_20, '0']
- [rtlsdr_source_17, '0', analog_agc_xx_18, '0']
- [rtlsdr_source_17, '0', qtgui_freq_sink_x_22, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
