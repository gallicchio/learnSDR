options:
  parameters:
    author: Claude (Oct 2026), in the style of the learnSDR lessons
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson33_B210_Two_Antenna_Phase
    output_language: python
    title: 'Two antennas on a USRP B210: phase difference and direction'
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: B210 RX gain, both channels
    start: '0'
    step: '1'
    stop: '76'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tone_freq
  id: variable
  parameters:
    comment: the Pluto sends a tone this far from center_freq
    value: 20e3
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '10'
  states: {}
- name: analog_sig_source_x_7
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: 'Lesson 9: the Pluto transmits a tone'
    freq: tone_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_arg_13
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_11
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: |-
      ch0 x conj(ch1): the tone cancels, the phase
      difference remains (Lesson 3a: dividing complex numbers
      subtracts their angles)
  states: {}
- name: blocks_multiply_const_vxx_14
  id: blocks_multiply_const_vxx
  parameters:
    comment: radians -> degrees
    const: 180/math.pi
    type: float
  states: {}
- name: iio_pluto_sink_8
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(center_freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_4
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_12
  id: low_pass_filter
  parameters:
    comment: |-
      average over 100 samples and drop everything
      that is not the tone
    cutoff_freq: 1e3
    decim: '100'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_17
  id: qtgui_const_sink_x
  parameters:
    label1: phasor
    name: '"ch0 x conj(ch1)"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_10
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: channel 0
    label2: channel 1
    name: '"The two channels"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_number_sink_16
  id: qtgui_number_sink
  parameters:
    avg: '0.1'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: ch0 - ch1
    max: '180'
    min: '-180'
    name: '"Phase difference"'
    type: float
    unit1: deg
  states: {}
- name: qtgui_time_sink_x_15
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      move the Pluto (or an antenna) by a few cm at 915 MHz
      (wavelength 33 cm) and watch this change.
      A 1/4 wavelength path difference is 90 degrees.
    label1: degrees
    name: '"Phase difference between the antennas"'
    size: '1024'
    srate: samp_rate/100
    type: float
    ymax: '180'
    ymin: '-180'
  states: {}
- name: uhd_usrp_source_9
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: center_freq
    center_freq1: center_freq
    comment: |-
      B210 with TWO receive channels (RX2 of side A and side B).
      Both channels share the same local oscillator, so the
      phase difference between them is stable and only depends
      on the geometry: path-length difference x 2 pi / wavelength
    dev_args: '""'
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_7, '0', iio_pluto_sink_8, '0']
- [blocks_complex_to_arg_13, '0', blocks_multiply_const_vxx_14, '0']
- [blocks_multiply_conjugate_cc_11, '0', low_pass_filter_12, '0']
- [blocks_multiply_const_vxx_14, '0', qtgui_number_sink_16, '0']
- [blocks_multiply_const_vxx_14, '0', qtgui_time_sink_x_15, '0']
- [low_pass_filter_12, '0', blocks_complex_to_arg_13, '0']
- [low_pass_filter_12, '0', qtgui_const_sink_x_17, '0']
- [uhd_usrp_source_9, '0', blocks_multiply_conjugate_cc_11, '0']
- [uhd_usrp_source_9, '0', qtgui_freq_sink_x_10, '0']
- [uhd_usrp_source_9, '1', blocks_multiply_conjugate_cc_11, '1']
- [uhd_usrp_source_9, '1', qtgui_freq_sink_x_10, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
