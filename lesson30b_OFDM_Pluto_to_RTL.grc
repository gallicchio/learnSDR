options:
  parameters:
    author: Claude (Oct 2026), in the style of the learnSDR lessons
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson30b_OFDM_Pluto_to_RTL
    output_language: python
    title: OFDM from Pluto to RTL-SDR
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: cp_len
  id: variable
  parameters:
    comment: |-
      cyclic prefix: the last 16 samples of each
      symbol are copied in front of it
    value: fft_len//4
  states: {}
- name: fft_len
  id: variable
  parameters:
    comment: number of sub-carriers (including unused ones)
    value: '64'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    comment: name of the tag that marks packet boundaries
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    comment: 48 data carriers (the same layout as Wi-Fi 802.11a)
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    comment: payload bytes per packet
    value: '96'
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    comment: |-
      4 pilot carriers with known symbols, used by
      the receiver to track phase and frequency
    value: ((-21, -7, 7, 21),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1),)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '49'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '10'
  states: {}
- name: analog_random_source_x_12
  id: analog_random_source_x
  parameters:
    comment: random bytes
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_15
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      OFDM has a high peak-to-average ratio:
      keep the average well below the Pluto's limit
    const: '0.1'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_13
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: cut the byte stream into packets
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tag_debug_23
  id: blocks_tag_debug
  parameters:
    comment: |-
      prints the rx_len tags (one per received packet)
      to the console
    name: '"rx packets"'
    type: byte
  states: {}
- name: blocks_uchar_to_float_21
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_ofdm_rx_20
  id: digital_ofdm_rx
  parameters:
    comment: |-
      OFDM receiver: finds the packet start (Schmidl & Cox
      sync word), corrects the frequency offset, FFT, equalizes
      each carrier with the pilots, decodes header then payload
    cp_len: cp_len
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_14
  id: digital_ofdm_tx
  parameters:
    comment: |-
      OFDM transmitter: header (BPSK) + payload (QPSK) symbols
      are put on the sub-carriers, an inverse FFT turns them into
      a time signal, and the cyclic prefix is added
    cp_len: cp_len
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: iio_pluto_sink_16
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(center_freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: qtgui_freq_sink_x_18
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 'flat top: every sub-carrier carries the same power'
    fc: '0'
    fftsize: '2048'
    label1: RTL-SDR
    name: '"Received OFDM spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_19
  id: qtgui_time_sink_x
  parameters:
    comment: bursts = packets; the signal looks like noise
    label1: re
    label2: im
    name: '"OFDM in time"'
    size: '4096'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_22
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      random bytes in, the same random bytes out
      (compare with the console: tag debug)
    label1: decoded payload bytes
    name: '"Received bytes"'
    size: '400'
    srate: samp_rate
    type: float
    ymax: '256'
    ymin: '0'
  states: {}
- name: rtlsdr_source_17
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    comment: |-
      the RTL-SDR clock error (about 1 carrier spacing here)
      is removed by the OFDM receiver's sync word and pilots
    freq0: center_freq
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_random_source_x_12, '0', blocks_stream_to_tagged_stream_13, '0']
- [blocks_multiply_const_vxx_15, '0', iio_pluto_sink_16, '0']
- [blocks_stream_to_tagged_stream_13, '0', digital_ofdm_tx_14, '0']
- [blocks_uchar_to_float_21, '0', qtgui_time_sink_x_22, '0']
- [digital_ofdm_rx_20, '0', blocks_tag_debug_23, '0']
- [digital_ofdm_rx_20, '0', blocks_uchar_to_float_21, '0']
- [digital_ofdm_tx_14, '0', blocks_multiply_const_vxx_15, '0']
- [rtlsdr_source_17, '0', digital_ofdm_rx_20, '0']
- [rtlsdr_source_17, '0', qtgui_freq_sink_x_18, '0']
- [rtlsdr_source_17, '0', qtgui_time_sink_x_19, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
