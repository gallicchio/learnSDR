options:
  parameters:
    author: jason
    generate_options: qt_gui
    id: GPS_RTL_SDR
    output_language: python
    title: GPS_RTL_SDR
  states: {}

blocks:
- name: GPS_ID
  id: variable
  parameters:
    value: '32'
  states: {}
- name: Ncycles
  id: variable
  parameters:
    value: '4'
  states: {}
- name: doppler_shift
  id: variable_qtgui_range
  parameters:
    start: '-5e3'
    step: '50'
    stop: 5e3
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '80'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: vector_size
  id: variable
  parameters:
    value: int(Ncycles*samp_rate/1000)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: doppler_shift
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vector_size
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/vector_size]*vector_size'
    type: complex
    vlen: vector_size
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: cacodes[GPS_ID]
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    comment: |-
      In a real system, this one can be 
      pre-computed for each satellite
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from GPScacodes import cacodes
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1000'
    decim: int(samp_rate/1000)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    label1: Once Cycle of CA Code Resampled
    label2: RTL-SDR raw
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: One Cycle of CA Code (1023 chips)
    label2: One Cycle of CA Code Im (zero)
    marker1: '0'
    size: '1023'
    srate: '1'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Once Cycle of CA Code Resampled
    label2: Once Cycle of CA Code Resampled Im (zero)
    size: int(samp_rate/1000)
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: RTL-SDR raw Re
    label2: RTL-SDR raw Im
    size: int(samp_rate/1000)
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Correlation Re
    label2: Correlation Im
    size: vector_size
    srate: samp_rate
    type: complex
    ymax: vector_size*1.2
    ymin: '-vector_size*0.2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    label1: Correlation Mag
    size: vector_size
    srate: samp_rate
    type: float
    ymax: 25*Ncycles
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: Correlate Against Each Cycle Re
    label2: Correlate Against Each Cycle Im
    size: 20*10
    srate: 1e3
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: 1023*1000
    interp: int(samp_rate)
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl,bias=1"'
    bb_gain0: '20'
    comment: |-
      Add "rtl,bias=1" to 
      Device Arguments arguments 
      to turn on the bias T
      Tune to 1575.42 MHz for GPS L1
    freq0: 1575.42e6
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0, '0']
- [blocks_vector_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', rational_resampler_xxx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0_2, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_1, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '1']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0_1_0, '0']

metadata:
  file_format: 1
