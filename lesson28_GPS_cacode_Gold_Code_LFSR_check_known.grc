options:
  parameters:
    author: jason
    generate_options: qt_gui
    id: GPS_cacode_Gold_Code_LFSR
    output_language: python
    title: GPS_cacode_Gold_Code_LFSR
  states: {}

blocks:
- name: GPS_ID
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1023e3
  states: {}
- name: vector_size
  id: variable
  parameters:
    value: 2**10-1
  states: {}
- name: vector_size_0
  id: variable
  parameters:
    value: 2**10-1
  states: {}
- name: vector_size_0_0
  id: variable
  parameters:
    value: 2**10-1
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_1_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: offset plot
    const: '2'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    comment: offset plot
    const: '4'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    comment: offset plot
    const: '6'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    comment: offset plot
    const: '8'
    type: byte
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '6'
    type: float
  states: {}
- name: blocks_add_const_vxx_2
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_2_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1_0_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_3
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_3_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: '1'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    comment: '2'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    comment: '3'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    comment: '4'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    comment: '5'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    comment: '6'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    comment: '7'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    comment: '10'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    comment: '10'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    comment: '10'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    comment: '10'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_1
  id: blocks_delay
  parameters:
    comment: '7'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_1_0
  id: blocks_delay
  parameters:
    comment: '7'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_1_0_0
  id: blocks_delay
  parameters:
    comment: '7'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_1
  id: blocks_delay
  parameters:
    comment: '9'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_1_0
  id: blocks_delay
  parameters:
    comment: '9'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_1_0_0
  id: blocks_delay
  parameters:
    comment: '9'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_1_0_0_0
  id: blocks_delay
  parameters:
    comment: '9'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_2
  id: blocks_delay
  parameters:
    comment: '6'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_2_0
  id: blocks_delay
  parameters:
    comment: '6'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_2_0_0
  id: blocks_delay
  parameters:
    comment: '6'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_1
  id: blocks_delay
  parameters:
    comment: '8'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_1_0
  id: blocks_delay
  parameters:
    comment: '8'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_1_0_0
  id: blocks_delay
  parameters:
    comment: '8'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_1_0_0_0
  id: blocks_delay
  parameters:
    comment: '8'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_2
  id: blocks_delay
  parameters:
    comment: '5'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_2_0
  id: blocks_delay
  parameters:
    comment: '5'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_2_0_0
  id: blocks_delay
  parameters:
    comment: '5'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_1
  id: blocks_delay
  parameters:
    comment: '4'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_1_0
  id: blocks_delay
  parameters:
    comment: '4'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_1_0_0
  id: blocks_delay
  parameters:
    comment: '4'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_1
  id: blocks_delay
  parameters:
    comment: '3'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_1_0
  id: blocks_delay
  parameters:
    comment: '3'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_1_0_0
  id: blocks_delay
  parameters:
    comment: '3'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_1
  id: blocks_delay
  parameters:
    comment: '2'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_1_0
  id: blocks_delay
  parameters:
    comment: '2'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_1_0_0
  id: blocks_delay
  parameters:
    comment: '2'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    comment: '1'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    comment: '1'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_1_0_0
  id: blocks_delay
  parameters:
    comment: '1'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_1_0_0_0
  id: blocks_delay
  parameters:
    comment: |-
      to allow the Delay blocks
      in the Scrambler LFSR
      to populate with valid data
    delay: '10'
    type: float
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '.5'
  states: {}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '.5'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vector_size
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vector_size
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vector_size
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/vector_size]*vector_size'
    type: complex
    vlen: vector_size
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/vector_size]*vector_size'
    type: complex
    vlen: vector_size
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/vector_size]*vector_size'
    type: complex
    vlen: vector_size
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: cacodes[GPS_ID]
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    comment: SV1 taps 2,6
    type: byte
  states: {}
- name: blocks_xor_xx_0_0
  id: blocks_xor_xx
  parameters:
    comment: SV2 taps 3,7
    type: byte
  states: {}
- name: blocks_xor_xx_1
  id: blocks_xor_xx
  parameters:
    comment: SV1 cacode
    type: byte
  states: {}
- name: blocks_xor_xx_1_0
  id: blocks_xor_xx
  parameters:
    comment: SV2 cacode
    type: byte
  states: {}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    comment: |-
      Default for 10 is a shifted
      version G1 LFSR: LFSR: x^10+x^3+1
      Looks like you need to subtract 1 from each power in the mask
      This becomes 2**(10-1) + 2**(3-1).
      Or you could do it normally and then shift right by 1.
      The difference between GLFSR and Scrambler LFSR 
      is a shift, but the amount of shift depends on the polynomial.
      Also, this outputs a float +1 and -1 and needs to be turned into 0s and 1s
    degree: '10'
    mask: 2**(10-1) + 2**(3-1)
    repeat: 'True'
    seed: 2**10-1
    type: float
  states: {}
- name: digital_glfsr_source_x_1
  id: digital_glfsr_source_x
  parameters:
    degree: '10'
    mask: 2**(10-1) + 2**(9-1) + 2**(8-1) + 2**(6-1) + 2**(3-1) + 2**(2-1)
    repeat: 'True'
    seed: 2**10-1
    type: float
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_map_bb_0_0_1
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_map_bb_0_0_2
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_scrambler_bb_1_0
  id: digital_scrambler_bb
  parameters:
    comment: |-
      G1 LFSR: x^10+x^3+1
      For the scrambler,
      length really means length-1
      GPS documentation's definition 
      of the bits is the opposite order
    len: 10-1
    mask: 2**(10-10) + 2**(10-3)
    seed: 2**10-1
  states: {}
- name: digital_scrambler_bb_1_0_0
  id: digital_scrambler_bb
  parameters:
    comment: 'G2 LFSR:  x^10+x^9+x^8+x^6+x^3+x^2+1'
    len: 10-1
    mask: 2**(10-10) + 2**(10-9) + 2**(10-8) + 2**(10-6) + 2**(10-3) + 2**(10-2)
    seed: 2**10-1
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_0_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_1_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_1_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_1_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from GPScacodes import cacodes
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: One Cycle of SV1's CA Code (1023 chips)
    label2: One Cycle of G1 LFSR
    label3: One Cycle of G2 LFSR
    label4: Gold Code for SV1
    label5: Gold Code for SV2
    marker1: '0'
    marker2: '0'
    marker3: '0'
    marker4: '0'
    marker5: '0'
    nconnections: '5'
    size: '1023'
    srate: '1'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: One Cycle of GLFSR 1
    label2: One Cycle of G1 LFSR
    label3: One Cycle of G2 LFSR
    label4: One Cycle of GLFSR 2
    marker1: '0'
    marker2: '0'
    marker3: '0'
    marker4: '0'
    nconnections: '4'
    size: '1023'
    srate: '1023'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: FFT corr re between SV1's CA and Gold Code
    label2: FFT corr im between SV1's CA and Gold Code
    marker1: '0'
    marker2: '0'
    size: vector_size
    srate: '1'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: FFT corr re between G1 and GLFSR1
    label2: FFT corr im between G1 and GLFSR1
    marker1: '0'
    marker2: '0'
    size: vector_size
    srate: '1'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: FFT corr re between G2 and GLFSR2
    label2: FFT corr im between G2 and GLFSR2
    marker1: '0'
    marker2: '0'
    size: vector_size
    srate: '1'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: GLFSR1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: GLFSR2
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: G2
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: G1
  states: {}
- name: virtual_sink_0_0_0_2
  id: virtual_sink
  parameters:
    stream_id: SV1CA
  states: {}
- name: virtual_sink_0_0_0_2_0
  id: virtual_sink
  parameters:
    stream_id: SV2CA
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: SV1CA
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: G1
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: GLFSR1
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: G2
  states: {}
- name: virtual_source_0_3
  id: virtual_source
  parameters:
    stream_id: GLFSR2
  states: {}

connections:
- [analog_const_source_x_0, '0', digital_scrambler_bb_1_0, '0']
- [analog_const_source_x_0, '0', digital_scrambler_bb_1_0_0, '0']
- [analog_const_source_x_1, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_1, '0', blocks_float_to_complex_1, '1']
- [analog_const_source_x_1_0, '0', blocks_float_to_complex_0_0, '1']
- [analog_const_source_x_1_0, '0', blocks_float_to_complex_1_0, '1']
- [analog_const_source_x_1_0_0, '0', blocks_float_to_complex_0_0_0, '1']
- [analog_const_source_x_1_0_0, '0', blocks_float_to_complex_1_0_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', blocks_char_to_float_0_0_0_0_0, '0']
- [blocks_add_const_vxx_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0, '0']
- [blocks_add_const_vxx_1, '0', qtgui_time_sink_x_0_0, '3']
- [blocks_add_const_vxx_2, '0', blocks_float_to_char_0, '0']
- [blocks_add_const_vxx_2_0, '0', blocks_float_to_char_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_char_to_float_0_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_char_to_float_0_0_0_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_char_to_float_0_0_0_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_char_to_float_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_char_to_float_0_0_0_0_0_1, '0', blocks_float_to_complex_1, '0']
- [blocks_char_to_float_0_0_0_0_0_1_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_char_to_float_0_0_0_0_0_1_0_0, '0', blocks_float_to_complex_1_0, '0']
- [blocks_char_to_float_0_0_0_0_0_1_0_1, '0', blocks_float_to_complex_0_0_0, '0']
- [blocks_char_to_float_0_0_0_0_0_1_0_2, '0', blocks_float_to_complex_1_0_0, '0']
- [blocks_char_to_float_0_0_0_3, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0_0_3_1, '0', blocks_add_const_vxx_1, '0']
- [blocks_delay_0, '0', blocks_delay_0_0, '0']
- [blocks_delay_0_0, '0', blocks_delay_0_0_0, '0']
- [blocks_delay_0_0, '0', blocks_xor_xx_0, '1']
- [blocks_delay_0_0_0, '0', blocks_delay_0_0_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_xor_xx_0_0, '1']
- [blocks_delay_0_0_0_0, '0', blocks_delay_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0, '0', blocks_delay_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0, '0', blocks_delay_0_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0, '0', blocks_xor_xx_0, '0']
- [blocks_delay_0_0_0_0_0_0_0, '0', blocks_delay_0_0_0_0_0_1, '0']
- [blocks_delay_0_0_0_0_0_0_0, '0', blocks_xor_xx_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_0, '0', virtual_sink_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_0_0, '0', blocks_xor_xx_1, '0']
- [blocks_delay_0_0_0_0_0_0_0_0_0, '0', blocks_xor_xx_1_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_0_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_0_0_0, '0', blocks_char_to_float_0_0_0_3, '0']
- [blocks_delay_0_0_0_0_0_0_0_0_0_0, '0', virtual_sink_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_0_0_0_0, '0', blocks_char_to_float_0_0_0_3_1, '0']
- [blocks_delay_0_0_0_0_0_0_0_0_0_0_0, '0', virtual_sink_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_1, '0', blocks_delay_0_0_0_0_0_1_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_1_0, '0', blocks_delay_0_0_0_0_0_1_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_1_0_0, '0', blocks_delay_0_0_0_0_0_1_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_1, '0', blocks_delay_0_0_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_1_0, '0', blocks_delay_0_0_0_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_1_0_0, '0', blocks_delay_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_1_0_0_0, '0', blocks_delay_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_2, '0', blocks_delay_0_0_0_0_0_0_0_1, '0']
- [blocks_delay_0_0_0_0_0_0_2_0, '0', blocks_delay_0_0_0_0_0_0_0_1_0, '0']
- [blocks_delay_0_0_0_0_0_0_2_0_0, '0', blocks_delay_0_0_0_0_0_0_0_1_0_0, '0']
- [blocks_delay_0_0_0_0_0_1, '0', blocks_delay_0_0_0_0_0_0_1, '0']
- [blocks_delay_0_0_0_0_0_1_0, '0', blocks_delay_0_0_0_0_0_0_1_0, '0']
- [blocks_delay_0_0_0_0_0_1_0_0, '0', blocks_delay_0_0_0_0_0_0_1_0_0, '0']
- [blocks_delay_0_0_0_0_0_1_0_0_0, '0', blocks_delay_0_0_0_0_0_0_1_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_2, '0', blocks_delay_0_0_0_0_0_0_2, '0']
- [blocks_delay_0_0_0_0_0_2_0, '0', blocks_delay_0_0_0_0_0_0_2_0, '0']
- [blocks_delay_0_0_0_0_0_2_0_0, '0', blocks_delay_0_0_0_0_0_0_2_0_0, '0']
- [blocks_delay_0_0_0_0_1, '0', blocks_delay_0_0_0_0_0_2, '0']
- [blocks_delay_0_0_0_0_1_0, '0', blocks_delay_0_0_0_0_0_2_0, '0']
- [blocks_delay_0_0_0_0_1_0_0, '0', blocks_delay_0_0_0_0_0_2_0_0, '0']
- [blocks_delay_0_0_0_1, '0', blocks_delay_0_0_0_0_1, '0']
- [blocks_delay_0_0_0_1_0, '0', blocks_delay_0_0_0_0_1_0, '0']
- [blocks_delay_0_0_0_1_0_0, '0', blocks_delay_0_0_0_0_1_0_0, '0']
- [blocks_delay_0_0_1, '0', blocks_delay_0_0_0_1, '0']
- [blocks_delay_0_0_1_0, '0', blocks_delay_0_0_0_1_0, '0']
- [blocks_delay_0_0_1_0_0, '0', blocks_delay_0_0_0_1_0_0, '0']
- [blocks_delay_0_1, '0', blocks_delay_0_0_1, '0']
- [blocks_delay_0_1_0, '0', blocks_delay_0_0_1_0, '0']
- [blocks_delay_0_1_0_0, '0', blocks_delay_0_0_1_0_0, '0']
- [blocks_delay_0_1_0_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_delay_0_1_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_char_0, '0', blocks_delay_0_1_0, '0']
- [blocks_float_to_char_0_0, '0', blocks_delay_0_1_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [blocks_float_to_complex_0_0_0, '0', blocks_stream_to_vector_0_0_0_0_0, '0']
- [blocks_float_to_complex_1, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_float_to_complex_1_0, '0', blocks_stream_to_vector_0_0_1, '0']
- [blocks_float_to_complex_1_0_0, '0', blocks_stream_to_vector_0_0_1_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_1, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', fft_vxx_1_0, '0']
- [blocks_multiply_conjugate_cc_0_0_0, '0', fft_vxx_1_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_0_0_0_0_0, '0', fft_vxx_0_1_0, '0']
- [blocks_stream_to_vector_0_0_1, '0', fft_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_0_1_0, '0', fft_vxx_0_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_delay_0_1_0_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_1_1, '0']
- [blocks_vector_to_stream_0_0_0, '0', qtgui_time_sink_x_1_1_0, '0']
- [blocks_xor_xx_0, '0', blocks_xor_xx_1, '1']
- [blocks_xor_xx_0_0, '0', blocks_xor_xx_1_0, '1']
- [blocks_xor_xx_1, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_xor_xx_1, '0', virtual_sink_0_0_0_2, '0']
- [blocks_xor_xx_1_0, '0', blocks_add_const_vxx_0_0_0_0, '0']
- [blocks_xor_xx_1_0, '0', virtual_sink_0_0_0_2_0, '0']
- [digital_glfsr_source_x_0, '0', blocks_add_const_vxx_2, '0']
- [digital_glfsr_source_x_1, '0', blocks_add_const_vxx_2_0, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0_0_0_0_0_1, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_0_0_0_0_0_1_0, '0']
- [digital_map_bb_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_1_0_0, '0']
- [digital_map_bb_0_0_1, '0', blocks_char_to_float_0_0_0_0_0_1_0_1, '0']
- [digital_map_bb_0_0_2, '0', blocks_char_to_float_0_0_0_0_0_1_0_2, '0']
- [digital_scrambler_bb_1_0, '0', blocks_delay_0_1, '0']
- [digital_scrambler_bb_1_0_0, '0', blocks_delay_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_0_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [fft_vxx_0_0_0_0, '0', blocks_multiply_conjugate_cc_0_0_0, '1']
- [fft_vxx_0_1, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [fft_vxx_0_1_0, '0', blocks_multiply_conjugate_cc_0_0_0, '0']
- [fft_vxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [fft_vxx_1_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [fft_vxx_1_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [virtual_source_0, '0', digital_map_bb_0, '0']
- [virtual_source_0_0, '0', digital_map_bb_0_0, '0']
- [virtual_source_0_1, '0', digital_map_bb_0_0_0, '0']
- [virtual_source_0_2, '0', digital_map_bb_0_0_1, '0']
- [virtual_source_0_3, '0', digital_map_bb_0_0_2, '0']

metadata:
  file_format: 1
