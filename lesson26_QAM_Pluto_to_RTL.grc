options:
  parameters:
    author: Claude (Oct 2026), in the style of the learnSDR lessons
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson26_QAM_Pluto_to_RTL
    output_language: python
    title: 8PSK and 16-QAM from Pluto to RTL-SDR
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    comment: |-
      Enable exactly ONE of these three constellation blocks.
      16-QAM: 4 bits per symbol, 3 amplitude rings
    precision: '8'
    type: 16qam
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    comment: '8PSK: 3 bits per symbol, one ring'
    precision: '8'
    rot_sym: '8'
    type: 8psk
  states: {state: disabled}
- name: constellation
  id: variable_constellation
  parameters:
    comment: QPSK, for comparison (Lesson 20)
    precision: '8'
    type: qpsk
  states: {state: disabled}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rcc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts*samp_rate, samp_rate/sps, alpha, 11*sps*nfilts)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '49'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: samples per symbol
    value: '16'
  states: {}
- name: ted_gain
  id: variable
  parameters:
    comment: see Lesson 18
    value: 1.1*alpha/sps
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '10'
  states: {}
- name: analog_agc_xx_20
  id: analog_agc_xx
  parameters:
    comment: |-
      reference 1 = mean amplitude 1, which is also
      how GNU Radio normalizes its 8PSK/16-QAM points
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_random_source_x_14
  id: analog_random_source_x
  parameters:
    comment: random bytes
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_complex_to_mag_squared_31
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_32
  id: blocks_moving_average_xx
  parameters:
    length: '2000'
    max_iter: '4000'
    scale: 1.0/2000
    type: float
  states: {}
- name: blocks_multiply_const_vxx_16
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      keep the peaks of the RRC-shaped signal
      well inside the Pluto's +/-1 range
    const: 0.3/np.max(np.abs(constellation.points()))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_29
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      scale the ideal points to mean amplitude 1
      (what the AGC gives us)
    const: 1/np.mean(np.abs(constellation.points()))
    type: complex
  states: {}
- name: blocks_nlog10_ff_33
  id: blocks_nlog10_ff
  parameters:
    comment: SNR (dB) = -10 log10(error power)
    k: '0'
    n: '-10'
  states: {}
- name: blocks_null_sink_27
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_skiphead_22
  id: blocks_skiphead
  parameters:
    comment: skip one second so the FLL has locked
    num_items: int(samp_rate)
    type: complex
  states: {}
- name: blocks_sub_xx_30
  id: blocks_sub_xx
  parameters:
    comment: error vector
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_28
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: the decided symbol index back to a complex number
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: constellation.points()
  states: {}
- name: digital_constellation_modulator_15
  id: digital_constellation_modulator
  parameters:
    comment: |-
      the Constellation Modulator packs the bits
      into symbols for whatever constellation it is given
    constellation: constellation
    differential: 'False'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_receiver_cb_24
  id: digital_constellation_receiver_cb
  parameters:
    comment: |-
      Constellation Receiver = a Costas-style phase loop whose
      error signal is "received symbol minus nearest constellation
      point". Unlike the plain Costas loop (Lesson 19) it works for
      any constellation, including the three rings of 16-QAM.
      Outputs: decided symbol index (byte) and, on the "symbol" port,
      the phase-corrected complex symbol.
    constellation: constellation
    fmax: '0.1'
    fmin: '-0.1'
    loop_bw: 2*math.pi/100
    showports: 'True'
  states: {}
- name: digital_fll_band_edge_cc_21
  id: digital_fll_band_edge_cc
  parameters:
    comment: Lesson 17
    filter_size: sps*2+1
    improved_loop_filter: 'False'
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: 2*math.pi/sps/100
  states: {}
- name: digital_symbol_sync_xx_23
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      Lesson 18. The signal-times-slope TED still works
      for QAM: all rings share the same symbol timing
    constellation: constellation
    damping: '1.0'
    loop_bw: '0.02'
    max_dev: '0.1'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rcc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: ted_gain
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: iio_pluto_sink_17
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(center_freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_8
  id: import
  parameters:
    imports: |-
      import math
      import numpy as np
      from gnuradio import gr
      from gnuradio.filter import firdes
  states: {}
- name: qtgui_const_sink_x_26
  id: qtgui_const_sink_x
  parameters:
    label1: after phase recovery
    name: '"Received constellation"'
    size: '4096'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_18
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    label1: TX
    name: '"Transmitted spectrum"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_25
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    label1: RTL-SDR raw
    label2: after FLL
    name: '"Received spectrum"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_number_sink_34
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: SNR
    max: '40'
    min: '0'
    name: '"SNR from the error vector"'
    type: float
    unit1: dB
  states: {}
- name: rtlsdr_source_19
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_20, '0', digital_fll_band_edge_cc_21, '0']
- [analog_random_source_x_14, '0', digital_constellation_modulator_15, '0']
- [blocks_complex_to_mag_squared_31, '0', blocks_moving_average_xx_32, '0']
- [blocks_moving_average_xx_32, '0', blocks_nlog10_ff_33, '0']
- [blocks_multiply_const_vxx_16, '0', iio_pluto_sink_17, '0']
- [blocks_multiply_const_vxx_16, '0', qtgui_freq_sink_x_18, '0']
- [blocks_multiply_const_vxx_29, '0', blocks_sub_xx_30, '1']
- [blocks_nlog10_ff_33, '0', qtgui_number_sink_34, '0']
- [blocks_skiphead_22, '0', digital_symbol_sync_xx_23, '0']
- [blocks_sub_xx_30, '0', blocks_complex_to_mag_squared_31, '0']
- [digital_chunks_to_symbols_xx_28, '0', blocks_multiply_const_vxx_29, '0']
- [digital_constellation_modulator_15, '0', blocks_multiply_const_vxx_16, '0']
- [digital_constellation_receiver_cb_24, '0', digital_chunks_to_symbols_xx_28, '0']
- [digital_constellation_receiver_cb_24, '1', blocks_null_sink_27, '0']
- [digital_constellation_receiver_cb_24, '2', blocks_null_sink_27, '1']
- [digital_constellation_receiver_cb_24, '3', blocks_null_sink_27, '2']
- [digital_constellation_receiver_cb_24, '4', blocks_sub_xx_30, '0']
- [digital_constellation_receiver_cb_24, '4', qtgui_const_sink_x_26, '0']
- [digital_fll_band_edge_cc_21, '0', blocks_skiphead_22, '0']
- [digital_fll_band_edge_cc_21, '0', qtgui_freq_sink_x_25, '1']
- [digital_symbol_sync_xx_23, '0', digital_constellation_receiver_cb_24, '0']
- [rtlsdr_source_19, '0', analog_agc_xx_20, '0']
- [rtlsdr_source_19, '0', qtgui_freq_sink_x_25, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
