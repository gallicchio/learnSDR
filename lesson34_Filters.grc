options:
  parameters:
    author: Claude (Oct 2026), in the style of the learnSDR lessons
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson34_Filters
    output_language: python
    title: 'Filters: low-pass, high-pass, band-pass, transition width and decimation (simulation)'
  states: {}

blocks:
- name: cutoff
  id: variable_qtgui_range
  parameters:
    comment: where the filter starts to roll off (Hz)
    start: 10e3
    step: 1e3
    stop: 450e3
    value: 100e3
  states: {}
- name: decimation
  id: variable
  parameters:
    comment: keep one sample in 10 after the filter
    value: '10'
  states: {}
- name: ntaps
  id: variable
  parameters:
    comment: how long the low-pass filter is
    value: len(firdes.low_pass(1, samp_rate, cutoff, transition))
  states: {}
- name: ntaps_label
  id: variable_qtgui_label
  parameters:
    comment: |-
      every output sample costs this many multiplications;
      halve the transition width and watch it double
    label: '"Low-pass filter length (taps)"'
    type: int
    value: ntaps
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: transition
  id: variable_qtgui_range
  parameters:
    comment: |-
      how fast it rolls off (Hz). Narrower = more taps = more CPU:
      number of taps is roughly 4 * samp_rate / transition
    start: 2e3
    step: 1e3
    stop: 200e3
    value: 50e3
  states: {}
- name: analog_noise_source_x_7
  id: analog_noise_source_x
  parameters:
    amp: '1'
    comment: |-
      white noise: every frequency equally present,
      so the output spectrum IS the filter response
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: band_pass_filter_11
  id: band_pass_filter
  parameters:
    comment: |-
      complex taps: keeps cutoff < f < cutoff+100k
      (positive frequencies only - a real-tap filter
      would also keep the negative-frequency image)
    decim: '1'
    gain: '1'
    high_cutoff_freq: cutoff+100e3
    low_cutoff_freq: cutoff
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: blocks_throttle2_8
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: high_pass_filter_10
  id: high_pass_filter
  parameters:
    comment: keeps |f| > cutoff
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: import_2
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: low_pass_filter_14
  id: low_pass_filter
  parameters:
    comment: |-
      decimating filter: the cutoff must be below the NEW
      Nyquist frequency samp_rate/decimation/2, or the part
      above it folds back (aliases, Lesson 6). The filter only
      computes the outputs it keeps, so this costs 1/10 the CPU
    cutoff_freq: samp_rate/decimation/2*0.8
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/decimation/2*0.2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_9
  id: low_pass_filter
  parameters:
    comment: keeps |f| < cutoff
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_12
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: unfiltered noise
    label2: low-pass
    label3: high-pass
    label4: band-pass (complex)
    name: '"Filter responses (white noise in)"'
    nconnections: '4'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_15
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    comment: |-
      the same noise, now only 100 kHz wide,
      at a tenth of the sample rate
    fc: '0'
    fftsize: '1024'
    label1: 100 kS/s
    name: '"After decimation by 10"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_17
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*3/2
    comment: |-
      the noise still occupies 1 MHz; the extra
      500 kHz is empty, which is the sign of a good resampler
    fc: '0'
    fftsize: '1024'
    label1: 1.5 MS/s
    name: '"After resampling by 3/2"'
    type: complex
  states: {}
- name: rational_resampler_xxx_16
  id: rational_resampler_xxx
  parameters:
    comment: |-
      rational resampler: x3 up, /2 down = 1.5 MS/s.
      Internally: insert zeros, low-pass, keep 1 in 2,
      all done as one polyphase filter
    decim: '2'
    interp: '3'
    type: ccc
  states: {}

connections:
- [analog_noise_source_x_7, '0', blocks_throttle2_8, '0']
- [band_pass_filter_11, '0', qtgui_freq_sink_x_12, '3']
- [blocks_throttle2_8, '0', band_pass_filter_11, '0']
- [blocks_throttle2_8, '0', high_pass_filter_10, '0']
- [blocks_throttle2_8, '0', low_pass_filter_14, '0']
- [blocks_throttle2_8, '0', low_pass_filter_9, '0']
- [blocks_throttle2_8, '0', qtgui_freq_sink_x_12, '0']
- [blocks_throttle2_8, '0', rational_resampler_xxx_16, '0']
- [high_pass_filter_10, '0', qtgui_freq_sink_x_12, '2']
- [low_pass_filter_14, '0', qtgui_freq_sink_x_15, '0']
- [low_pass_filter_9, '0', qtgui_freq_sink_x_12, '1']
- [rational_resampler_xxx_16, '0', qtgui_freq_sink_x_17, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
