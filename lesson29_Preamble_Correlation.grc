options:
  parameters:
    author: Claude (Oct 2026), in the style of the learnSDR lessons
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson29_Preamble_Correlation
    output_language: python
    title: Finding packets and fixing the phase ambiguity with a known preamble (simulation)
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: fraction of the sample rate
    start: '-0.01'
    step: '0.0005'
    stop: '0.01'
    value: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: payload_len
  id: variable
  parameters:
    comment: random payload symbols per packet
    value: '100'
  states: {}
- name: preamble
  id: variable
  parameters:
    comment: the same bits as QPSK symbols (all on the +45/-135 degree diagonal)
    value: '[(b+1j*b)/np.sqrt(2) for b in preamble_bits]'
  states: {}
- name: preamble_bits
  id: variable
  parameters:
    comment: |-
      a 13-chip Barker code, twice. Barker codes have
      the smallest possible correlation sidelobes
    value: '[1,1,1,1,1,-1,-1,1,1,-1,1,-1,1, 1,1,1,1,1,-1,-1,1,1,-1,1,-1,1]'
  states: {}
- name: rcc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts*samp_rate, samp_rate/sps, alpha, 11*sps*nfilts)
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    comment: transmit pulse shape (Lesson 15)
    value: firdes.root_raised_cosine(sps, samp_rate, samp_rate/sps, alpha, 11*sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: ted_gain
  id: variable
  parameters:
    comment: see Lesson 18
    value: 1.1*alpha/sps
  states: {}
- name: analog_agc_xx_22
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_random_source_x_16
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_complex_to_arg_27
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_26
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_29
  id: blocks_multiply_const_vxx
  parameters:
    comment: phase / pi, to fit on the same plot
    const: 1/math.pi
    type: float
  states: {}
- name: blocks_stream_mux_18
  id: blocks_stream_mux
  parameters:
    comment: one packet = preamble followed by payload
    lengths: '[len(preamble), payload_len]'
    type: complex
  states: {}
- name: blocks_throttle2_20
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_15
  id: blocks_vector_source_x
  parameters:
    comment: the known preamble ...
    repeat: 'True'
    type: complex
    vector: preamble
  states: {}
- name: channels_channel_model_21
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: freq_offset
    noise_voltage: noise_voltage
    seed: '0'
    taps: '[1.0]'
  states: {}
- name: digital_chunks_to_symbols_xx_17
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: ... and random QPSK payload symbols
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: constellation.points()/np.abs(constellation.points()[0])
  states: {}
- name: digital_costas_loop_cc_24
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      Lesson 19: locks, but at one of FOUR equally
      good angles (0, 90, 180, 270 degrees)
    order: constellation.arity()
    w: 2*math.pi/100
  states: {}
- name: digital_symbol_sync_xx_23
  id: digital_symbol_sync_xx
  parameters:
    comment: Lesson 18
    constellation: constellation
    damping: '1.0'
    loop_bw: '0.02'
    max_dev: '0.1'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rcc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: ted_gain
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: fir_filter_xxx_25
  id: fir_filter_xxx
  parameters:
    comment: |-
      correlate with the preamble: an FIR filter whose taps are
      the time-reversed conjugate preamble (Lesson 22 did the same
      thing with FFTs). Output = 1 x e^(j*rotation) at a packet start
    decim: '1'
    taps: np.conj(preamble[::-1])/len(preamble)
    type: ccc
  states: {}
- name: import_9
  id: import
  parameters:
    imports: |-
      import math
      import numpy as np
      from gnuradio import gr
      from gnuradio.filter import firdes
  states: {}
- name: interp_fir_filter_xxx_19
  id: interp_fir_filter_xxx
  parameters:
    comment: |-
      root-raised-cosine pulse shaping (Lesson 15):
      this plus the symbol mapping is what the
      Constellation Modulator does inside
    interp: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: qtgui_const_sink_x_30
  id: qtgui_const_sink_x
  parameters:
    label1: after Costas loop
    name: '"Received symbols"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_time_sink_x_28
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      the phase at the peak is the Costas loop's rotation:
      0, +90, -90 or 180 degrees. Multiply the payload by
      e^(-j phase) and the ambiguity is gone.
    label1: '|correlation| (1 at each packet start)'
    label2: phase of correlation (degrees / 180)
    name: '"Correlation with the preamble"'
    nconnections: '2'
    size: 2*(len(preamble)+payload_len)
    srate: samp_rate/sps
    type: float
  states: {}

connections:
- [analog_agc_xx_22, '0', digital_symbol_sync_xx_23, '0']
- [analog_random_source_x_16, '0', digital_chunks_to_symbols_xx_17, '0']
- [blocks_complex_to_arg_27, '0', blocks_multiply_const_vxx_29, '0']
- [blocks_complex_to_mag_26, '0', qtgui_time_sink_x_28, '0']
- [blocks_multiply_const_vxx_29, '0', qtgui_time_sink_x_28, '1']
- [blocks_stream_mux_18, '0', interp_fir_filter_xxx_19, '0']
- [blocks_throttle2_20, '0', channels_channel_model_21, '0']
- [blocks_vector_source_x_15, '0', blocks_stream_mux_18, '0']
- [channels_channel_model_21, '0', analog_agc_xx_22, '0']
- [digital_chunks_to_symbols_xx_17, '0', blocks_stream_mux_18, '1']
- [digital_costas_loop_cc_24, '0', fir_filter_xxx_25, '0']
- [digital_costas_loop_cc_24, '0', qtgui_const_sink_x_30, '0']
- [digital_symbol_sync_xx_23, '0', digital_costas_loop_cc_24, '0']
- [fir_filter_xxx_25, '0', blocks_complex_to_arg_27, '0']
- [fir_filter_xxx_25, '0', blocks_complex_to_mag_26, '0']
- [interp_fir_filter_xxx_19, '0', blocks_throttle2_20, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
