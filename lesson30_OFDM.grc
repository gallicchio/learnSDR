options:
  parameters:
    author: Claude (Oct 2026), in the style of the learnSDR lessons
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson30_OFDM
    output_language: python
    title: 'OFDM: many slow carriers instead of one fast one (simulation)'
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    comment: |-
      cyclic prefix: the last 16 samples of each
      symbol are copied in front of it
    value: fft_len//4
  states: {}
- name: echo_amplitude
  id: variable_qtgui_range
  parameters:
    comment: |-
      two-path channel as in Lesson 28: an echo
      3 samples late. OFDM with a 16-sample cyclic
      prefix does not care, as long as the echo is
      shorter than the prefix
    start: '0'
    step: '0.01'
    stop: '0.9'
    value: '0.0'
  states: {}
- name: fft_len
  id: variable
  parameters:
    comment: number of sub-carriers (including unused ones)
    value: '64'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: |-
      carrier offset in units of the sub-carrier
      spacing (samp_rate/fft_len = 15.6 kHz)
    start: '-2'
    step: '0.1'
    stop: '2'
    value: '0'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    comment: name of the tag that marks packet boundaries
    value: '"packet_len"'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.005'
    stop: '0.2'
    value: '0.01'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    comment: 48 data carriers (the same layout as Wi-Fi 802.11a)
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    comment: payload bytes per packet
    value: '96'
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    comment: |-
      4 pilot carriers with known symbols, used by
      the receiver to track phase and frequency
    value: ((-21, -7, 7, 21),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1),)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_random_source_x_12
  id: analog_random_source_x
  parameters:
    comment: random bytes
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_19
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_17
  id: blocks_delay
  parameters:
    delay: '3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_15
  id: blocks_multiply_const_vxx
  parameters:
    comment: OFDM has a high peak-to-average ratio
    const: '0.05'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_18
  id: blocks_multiply_const_vxx
  parameters:
    const: echo_amplitude
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_13
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: cut the byte stream into packets
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tag_debug_26
  id: blocks_tag_debug
  parameters:
    comment: |-
      prints the rx_len tags (one per received packet)
      to the console
    name: '"rx packets"'
    type: byte
  states: {}
- name: blocks_throttle2_16
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_24
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: channels_channel_model_20
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: freq_offset/fft_len
    noise_voltage: noise_voltage
    seed: '0'
    taps: '[1.0]'
  states: {}
- name: digital_ofdm_rx_23
  id: digital_ofdm_rx
  parameters:
    comment: |-
      OFDM receiver: finds the packet start (Schmidl & Cox
      sync word), corrects the frequency offset, FFT, equalizes
      each carrier with the pilots, decodes header then payload
    cp_len: cp_len
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_14
  id: digital_ofdm_tx
  parameters:
    comment: |-
      OFDM transmitter: header (BPSK) + payload (QPSK) symbols
      are put on the sub-carriers, an inverse FFT turns them into
      a time signal, and the cyclic prefix is added
    cp_len: cp_len
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: qtgui_freq_sink_x_21
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 'flat top: every sub-carrier carries the same power'
    fc: '0'
    fftsize: '2048'
    label1: 48 carriers, 15.6 kHz apart
    name: '"OFDM spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_22
  id: qtgui_time_sink_x
  parameters:
    comment: bursts = packets; the signal looks like noise
    label1: re
    label2: im
    name: '"OFDM in time"'
    size: '4096'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_25
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      random bytes in, the same random bytes out
      (compare with the console: tag debug)
    label1: decoded payload bytes
    name: '"Received bytes"'
    size: '400'
    srate: samp_rate
    type: float
    ymax: '256'
    ymin: '0'
  states: {}

connections:
- [analog_random_source_x_12, '0', blocks_stream_to_tagged_stream_13, '0']
- [blocks_add_xx_19, '0', channels_channel_model_20, '0']
- [blocks_delay_17, '0', blocks_multiply_const_vxx_18, '0']
- [blocks_multiply_const_vxx_15, '0', blocks_throttle2_16, '0']
- [blocks_multiply_const_vxx_18, '0', blocks_add_xx_19, '1']
- [blocks_stream_to_tagged_stream_13, '0', digital_ofdm_tx_14, '0']
- [blocks_throttle2_16, '0', blocks_add_xx_19, '0']
- [blocks_throttle2_16, '0', blocks_delay_17, '0']
- [blocks_uchar_to_float_24, '0', qtgui_time_sink_x_25, '0']
- [channels_channel_model_20, '0', digital_ofdm_rx_23, '0']
- [channels_channel_model_20, '0', qtgui_freq_sink_x_21, '0']
- [channels_channel_model_20, '0', qtgui_time_sink_x_22, '0']
- [digital_ofdm_rx_23, '0', blocks_tag_debug_26, '0']
- [digital_ofdm_rx_23, '0', blocks_uchar_to_float_24, '0']
- [digital_ofdm_tx_14, '0', blocks_multiply_const_vxx_15, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
