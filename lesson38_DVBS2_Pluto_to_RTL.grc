options:
  parameters:
    author: Claude (Oct 2026), in the style of the learnSDR lessons
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson38_DVBS2_Pluto_to_RTL
    output_language: python
    title: 'A real standard: DVB-S2 (satellite TV) from Pluto to RTL-SDR'
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rcc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts*samp_rate, samp_rate/sps, rolloff, 11*sps*nfilts)
  states: {}
- name: rolloff
  id: variable
  parameters:
    comment: DVB-S2 allows 0.35, 0.25, 0.2
    value: '0.2'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(sps, samp_rate, samp_rate/sps, rolloff, 11*sps)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '49'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: 'samples per symbol: 500 ksymbol/s'
    value: '2'
  states: {}
- name: ted_gain
  id: variable
  parameters:
    comment: Lesson 18 formula (sps = 2 is at the edge of its validity)
    value: 1.1*rolloff/sps
  states: {}
- name: ts_packet
  id: variable
  parameters:
    comment: |-
      one fake MPEG transport-stream packet: a 0x47 sync byte
      and 187 bytes of payload. Real DVB-S2 carries video in these
    value: '[0x47] + [(37*i + 11) % 256 for i in range(187)]'
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '10'
  states: {}
- name: analog_agc_xx_27
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_22
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: complex
  states: {}
- name: blocks_skiphead_29
  id: blocks_skiphead
  parameters:
    num_items: int(samp_rate)
    type: complex
  states: {}
- name: blocks_vector_source_x_13
  id: blocks_vector_source_x
  parameters:
    comment: TS packets, over and over
    repeat: 'True'
    type: byte
    vector: ts_packet
  states: {}
- name: digital_costas_loop_cc_31
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      Lesson 19. The scrambled symbols are still
      plain QPSK, so it locks. Decoding the frames
      needs gr-dvbs2rx, a separate package
    order: '4'
    w: 2*math.pi/100
  states: {}
- name: digital_fll_band_edge_cc_28
  id: digital_fll_band_edge_cc
  parameters:
    comment: Lesson 17
    filter_size: sps*2+1
    improved_loop_filter: 'False'
    rolloff: rolloff
    samps_per_sym: sps
    type: cc
    w: 2*math.pi/sps/100
  states: {}
- name: digital_symbol_sync_xx_30
  id: digital_symbol_sync_xx
  parameters:
    comment: Lesson 18
    constellation: digital.constellation_qpsk().base()
    damping: '1.0'
    loop_bw: '0.02'
    max_dev: '0.1'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rcc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: ted_gain
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: dtv_dvb_bbheader_bb_14
  id: dtv_dvb_bbheader_bb
  parameters:
    comment: |-
      1. baseband framing: group packets into a 32208-bit
      "baseband frame" with a header (and a CRC per packet)
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    rolloff: RO_0_20
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bbscrambler_bb_15
  id: dtv_dvb_bbscrambler_bb
  parameters:
    comment: |-
      2. scramble with an LFSR (Lesson 21) so the
      bits look random whatever the video does
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bch_bb_16
  id: dtv_dvb_bch_bb
  parameters:
    comment: '3. outer code: BCH, fixes a few dozen bit errors per frame'
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_ldpc_bb_17
  id: dtv_dvb_ldpc_bb
  parameters:
    comment: |-
      4. inner code: LDPC rate 1/2, 64800 bits out per
      32208 in. This is what lets DVB-S2 work within
      1 dB of the Shannon limit (Lesson 36 for the idea)
    constellation: MOD_OTHER
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvbs2_interleaver_bb_18
  id: dtv_dvbs2_interleaver_bb
  parameters:
    comment: 5. bit interleaver (nothing to do for QPSK)
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate1: C1_2
  states: {}
- name: dtv_dvbs2_modulator_bc_19
  id: dtv_dvbs2_modulator_bc
  parameters:
    comment: 6. bits -> QPSK symbols
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_OFF
    rate1: C1_2
  states: {}
- name: dtv_dvbs2_physical_cc_20
  id: dtv_dvbs2_physical_cc
  parameters:
    comment: |-
      7. physical layer: a 90-symbol header (the preamble
      of Lesson 29) that tells the receiver the modulation
      and code rate, pilot blocks every 1440 symbols, and a
      Gold-code scrambling (Lesson 22) of all the symbols
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    goldcode: '0'
    pilots: PILOTS_ON
    rate1: C1_2
  states: {}
- name: fir_filter_xxx_21
  id: fir_filter_xxx
  parameters:
    comment: |-
      8. root-raised-cosine pulse shaping (Lesson 15). The
      modulator already put a zero between the symbols
      (2 samples per symbol); this filter fills them in
    decim: '1'
    taps: rrc_taps
    type: ccf
  states: {}
- name: iio_pluto_sink_23
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(center_freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_9
  id: import
  parameters:
    imports: |-
      import math
      from gnuradio import gr
      from gnuradio.filter import firdes
  states: {}
- name: qtgui_const_sink_x_25
  id: qtgui_const_sink_x
  parameters:
    label1: QPSK + the zero-stuffed samples
    name: '"Symbols out of the physical-layer block"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_33
  id: qtgui_const_sink_x
  parameters:
    label1: after Costas loop
    name: '"Received symbols"'
    size: '4096'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_24
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    label1: 500 kBaud QPSK, rolloff 0.2
    name: '"Transmitted DVB-S2 spectrum"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_32
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    label1: RTL-SDR
    name: '"Received spectrum"'
    type: complex
  states: {}
- name: rtlsdr_source_26
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_27, '0', digital_fll_band_edge_cc_28, '0']
- [blocks_multiply_const_vxx_22, '0', iio_pluto_sink_23, '0']
- [blocks_multiply_const_vxx_22, '0', qtgui_freq_sink_x_24, '0']
- [blocks_skiphead_29, '0', digital_symbol_sync_xx_30, '0']
- [blocks_vector_source_x_13, '0', dtv_dvb_bbheader_bb_14, '0']
- [digital_costas_loop_cc_31, '0', qtgui_const_sink_x_33, '0']
- [digital_fll_band_edge_cc_28, '0', blocks_skiphead_29, '0']
- [digital_symbol_sync_xx_30, '0', digital_costas_loop_cc_31, '0']
- [dtv_dvb_bbheader_bb_14, '0', dtv_dvb_bbscrambler_bb_15, '0']
- [dtv_dvb_bbscrambler_bb_15, '0', dtv_dvb_bch_bb_16, '0']
- [dtv_dvb_bch_bb_16, '0', dtv_dvb_ldpc_bb_17, '0']
- [dtv_dvb_ldpc_bb_17, '0', dtv_dvbs2_interleaver_bb_18, '0']
- [dtv_dvbs2_interleaver_bb_18, '0', dtv_dvbs2_modulator_bc_19, '0']
- [dtv_dvbs2_modulator_bc_19, '0', dtv_dvbs2_physical_cc_20, '0']
- [dtv_dvbs2_physical_cc_20, '0', fir_filter_xxx_21, '0']
- [dtv_dvbs2_physical_cc_20, '0', qtgui_const_sink_x_25, '0']
- [fir_filter_xxx_21, '0', blocks_multiply_const_vxx_22, '0']
- [rtlsdr_source_26, '0', analog_agc_xx_27, '0']
- [rtlsdr_source_26, '0', qtgui_freq_sink_x_32, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
