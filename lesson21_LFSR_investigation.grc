options:
  parameters:
    author: jason
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson21_LFSR_investigation
    output_language: python
    title: lesson28_LFSR_investigation
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: vector_size
  id: variable
  parameters:
    value: 2**16-1
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {}
- name: analog_const_source_x_0_0_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: shift for plot
    const: '2'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    comment: shift for plot
    const: '2'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    comment: shift for plot
    const: '2'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    comment: shift for plot
    const: '2'
    type: float
  states: {}
- name: blocks_add_const_vxx_2
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_2_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_2_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_2_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: |-
      GLFSR is shifted compared to Scrambler,
      but by an amount that depends on
      the degree and the polynomial
    delay: '7'
    type: byte
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    comment: |-
      GLFSR is shifted compared to Scrambler,
      but by an amount that depends on
      the degree and the polynomial
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    comment: |-
      GLFSR is shifted compared to Scrambler,
      but by an amount that depends on
      the degree and the polynomial
    delay: 2**16-58452
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    comment: |-
      GLFSR is shifted compared to Scrambler,
      but by an amount that depends on
      the degree and the polynomial
    delay: 2**16-64865
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '.5'
  states: {}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '.5'
  states: {}
- name: blocks_float_to_char_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '.5'
  states: {}
- name: blocks_float_to_char_0_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '.5'
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vector_size
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/vector_size]*vector_size'
    type: complex
    vlen: vector_size
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    comment: |-
      Default for 10 is a shifted
      version G1 LFSR: LFSR: x^10+x^3+1
      Looks like you need to subtract 1 from each power in the mask
      This becomes 2**(10-1) + 2**(3-1).
      Or you could do it normally and then shift right by 1.
      The difference between GLFSR and Scrambler LFSR 
      is a shift, but the amount of shift depends on the polynomial.
      Also, this outputs a float +1 and -1 and needs to be turned into 0s and 1s
    degree: '10'
    mask: 2**(10-1) + 2**(3-1)
    repeat: 'True'
    seed: 2**10-1
    type: float
  states: {}
- name: digital_glfsr_source_x_0_0
  id: digital_glfsr_source_x
  parameters:
    comment: |-
      GLFSR feedback polynomial: x^3+x^2+1
      Looks like you need to subtract 1 from each power in the mask
      This becomes 2**(3-1) + 2**(2-1).
      Or you could do it normally and then shift right by 1.
      The difference between GLFSR and Scrambler LFSR 
      is a shift, but the amount of shift depends on the polynomial.
      Also, this outputs a float +1 and -1 and needs to be turned into 0s and 1s
    degree: '3'
    mask: 2**(3-1) + 2**(2-1)
    repeat: 'True'
    seed: 2**3-1
    type: float
  states: {}
- name: digital_glfsr_source_x_0_0_0
  id: digital_glfsr_source_x
  parameters:
    comment: |-
      GLFSR feedback polynomial: x^16+x^15+x^13+x^4+1
      Looks like you need to subtract 1 from each power in the mask
      This becomes 2**(3-1) + 2**(2-1).
      Or you could do it normally and then shift right by 1.
      The difference between GLFSR and Scrambler LFSR 
      is a shift, but the amount of shift depends on the polynomial.
      Also, this outputs a float +1 and -1 and needs to be turned into 0s and 1s
    degree: '16'
    mask: 2**(16-1) + 2**(15-1) + 2**(13-1) + 2**(4-1)
    repeat: 'True'
    seed: 2**16-1
    type: float
  states: {}
- name: digital_glfsr_source_x_0_0_0_0
  id: digital_glfsr_source_x
  parameters:
    comment: |-
      GLFSR feedback polynomial: x^16+x^14+x^13+x^11+1
      Looks like you need to subtract 1 from each power in the mask
      This becomes 2**(3-1) + 2**(2-1).
      Or you could do it normally and then shift right by 1.
      The difference between GLFSR and Scrambler LFSR 
      is a shift, but the amount of shift depends on the polynomial.
      Also, this outputs a float +1 and -1 and needs to be turned into 0s and 1s
    degree: '16'
    mask: 2**(16-1) + 2**(14-1) + 2**(13-1) + 2**(11-1)
    repeat: 'True'
    seed: 2**16-1
    type: float
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_scrambler_bb_1_0
  id: digital_scrambler_bb
  parameters:
    comment: |-
      G1 LFSR: x^10+x^3+1
      For the scrambler,
      length really means length-1
      GPS documentation's definition 
      of the bits is the opposite order
    len: 10-1
    mask: 2**(10-10) + 2**(10-3)
    seed: 2**10-1
  states: {}
- name: digital_scrambler_bb_1_0_0
  id: digital_scrambler_bb
  parameters:
    comment: |-
      LFSR feedback polynomial: x^3+x^2+1
      For the scrambler,
      length really means length-1
    len: 3-1
    mask: 2**(3-3) + 2**(3-2)
    seed: 2**3-1
  states: {}
- name: digital_scrambler_bb_1_0_0_0
  id: digital_scrambler_bb
  parameters:
    comment: |-
      LFSR feedback polynomial: x^16+x^15+x^13+x^4+1
      For the scrambler,
      length really means length-1
    len: 16-1
    mask: 2**(16-16) + 2**(16-15) + 2**(16-13) + 2**(16-4)
    seed: 2**16-1
  states: {}
- name: digital_scrambler_bb_1_0_0_0_0
  id: digital_scrambler_bb
  parameters:
    comment: |-
      LFSR feedback polynomial: x^16+x^14+x^13+x^11+1
      For the scrambler,
      length really means length-1
    len: 16-1
    mask: 2**(16-16) + 2**(16-14) + 2**(16-13) + 2**(16-11)
    seed: 2**16-1
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_1_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: One Cycle of GLFSR 1
    label2: One Cycle of G1 LFSR
    marker1: '0'
    marker2: '0'
    nconnections: '2'
    size: '1023'
    srate: '1023'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: One Cycle of GLFSR 1
    label2: One Cycle of G1 LFSR
    marker1: '0'
    marker2: '0'
    nconnections: '2'
    size: 2**3-1
    srate: 2**3-1
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: One Cycle of GLFSR 1
    label2: One Cycle of G1 LFSR
    marker1: '0'
    marker2: '0'
    nconnections: '2'
    size: 2**16-1
    srate: 2**16-1
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: One Cycle of GLFSR 1
    label2: One Cycle of G1 LFSR
    marker1: '0'
    marker2: '0'
    nconnections: '2'
    size: 2**16-1
    srate: 2**16-1
    type: float
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: FFT corr re between G1 and GLFSR1
    label2: FFT corr im between G1 and GLFSR1
    marker1: '0'
    marker2: '0'
    size: vector_size
    srate: '1'
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', digital_scrambler_bb_1_0, '0']
- [analog_const_source_x_0_0, '0', digital_scrambler_bb_1_0_0, '0']
- [analog_const_source_x_0_0_0, '0', digital_scrambler_bb_1_0_0_0, '0']
- [analog_const_source_x_0_0_0_0, '0', digital_scrambler_bb_1_0_0_0_0, '0']
- [analog_const_source_x_1_0, '0', blocks_float_to_complex_0_0, '1']
- [analog_const_source_x_1_0, '0', blocks_float_to_complex_1_0, '1']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_add_const_vxx_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [blocks_add_const_vxx_2, '0', blocks_float_to_char_0, '0']
- [blocks_add_const_vxx_2_0, '0', blocks_float_to_char_0_0, '0']
- [blocks_add_const_vxx_2_0_0, '0', blocks_float_to_char_0_0_0, '0']
- [blocks_add_const_vxx_2_0_0_0, '0', blocks_float_to_char_0_0_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_char_to_float_0_0_0_0_0, '0', blocks_throttle_0_0_0_0, '0']
- [blocks_char_to_float_0_0_0_0_0_1_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_char_to_float_0_0_0_0_0_1_0_0, '0', blocks_float_to_complex_1_0, '0']
- [blocks_char_to_float_0_1, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_char_to_float_0_1_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_char_to_float_0_1_0_0, '0', blocks_add_const_vxx_0_0_0_0, '0']
- [blocks_delay_0, '0', blocks_char_to_float_0, '0']
- [blocks_delay_0_0, '0', blocks_char_to_float_0_1, '0']
- [blocks_delay_0_0_0, '0', blocks_char_to_float_0_1_0, '0']
- [blocks_delay_0_0_0_0, '0', blocks_char_to_float_0_1_0_0, '0']
- [blocks_delay_0_0_0_0, '0', digital_map_bb_0_0, '0']
- [blocks_float_to_char_0, '0', blocks_delay_0, '0']
- [blocks_float_to_char_0_0, '0', blocks_delay_0_0, '0']
- [blocks_float_to_char_0_0_0, '0', blocks_delay_0_0_0, '0']
- [blocks_float_to_char_0_0_0_0, '0', blocks_delay_0_0_0_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [blocks_float_to_complex_1_0, '0', blocks_stream_to_vector_0_0_1, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', fft_vxx_1_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_0_0_1, '0', fft_vxx_0_0_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_throttle_0_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [blocks_throttle_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '1']
- [blocks_throttle_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0, '1']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_1_1, '0']
- [digital_glfsr_source_x_0, '0', blocks_add_const_vxx_2, '0']
- [digital_glfsr_source_x_0_0, '0', blocks_add_const_vxx_2_0, '0']
- [digital_glfsr_source_x_0_0_0, '0', blocks_add_const_vxx_2_0_0, '0']
- [digital_glfsr_source_x_0_0_0_0, '0', blocks_add_const_vxx_2_0_0_0, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_0_0_0_0_0_1_0, '0']
- [digital_map_bb_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_1_0_0, '0']
- [digital_scrambler_bb_1_0, '0', blocks_char_to_float_0_0, '0']
- [digital_scrambler_bb_1_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [digital_scrambler_bb_1_0_0_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [digital_scrambler_bb_1_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0, '0']
- [digital_scrambler_bb_1_0_0_0_0, '0', digital_map_bb_0_0_0, '0']
- [fft_vxx_0_0_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [fft_vxx_0_1, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [fft_vxx_1_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
