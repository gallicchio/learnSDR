options:
  parameters:
    author: Claude (Oct 2026), in the style of the learnSDR lessons
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson27_Noise_SNR_Constellation
    output_language: python
    title: Noise, SNR and the constellation (simulation)
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    comment: RRC excess bandwidth
    value: '0.5'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: |-
      carrier offset as a fraction of the sample rate
      (0.001 = 1 kHz here)
    start: '-0.01'
    step: '0.0005'
    stop: '0.01'
    value: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    comment: |-
      RMS noise voltage per sample added by the
      Channel Model. The signal has unit power,
      so Es/N0 = 10*log10(sps/(2*noise_voltage**2)) dB
    start: '0'
    step: '0.01'
    stop: '1.0'
    value: '0.1'
  states: {}
- name: rcc_taps
  id: variable
  parameters:
    comment: |-
      matched-filter prototype for the Symbol Sync
      (same as Lesson 18)
    value: firdes.root_raised_cosine(nfilts, nfilts*samp_rate, samp_rate/sps, alpha, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: samples per symbol
    value: '8'
  states: {}
- name: ted_gain
  id: variable
  parameters:
    comment: see Lesson 18
    value: 1.1*alpha/sps
  states: {}
- name: analog_agc_xx_16
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_random_source_x_11
  id: analog_random_source_x
  parameters:
    comment: random bytes
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_complex_to_mag_squared_23
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_24
  id: blocks_moving_average_xx
  parameters:
    comment: mean error power over 2000 symbols
    length: '2000'
    max_iter: '4000'
    scale: 1.0/2000
    type: float
  states: {}
- name: blocks_multiply_const_vxx_27
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      GNU Radio's built-in QPSK points have magnitude 2;
      scale them to the unit magnitude the AGC gives us
    const: 1/abs(constellation.points()[0])
    type: complex
  states: {}
- name: blocks_nlog10_ff_25
  id: blocks_nlog10_ff
  parameters:
    comment: |-
      signal power is 1 after the AGC, so
      SNR (dB) = -10 log10(error power)
    k: '0'
    n: '-10'
  states: {}
- name: blocks_sub_xx_22
  id: blocks_sub_xx
  parameters:
    comment: error vector = received - ideal
    type: complex
  states: {}
- name: blocks_throttle2_13
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_14
  id: channels_channel_model
  parameters:
    comment: |-
      adds complex white Gaussian noise
      (and a carrier offset if you ask for one)
    epsilon: '1.0'
    freq_offset: freq_offset
    noise_voltage: noise_voltage
    seed: '0'
    taps: '[1.0]'
  states: {}
- name: digital_chunks_to_symbols_xx_21
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: '... back to a complex number: the "ideal" symbol'
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: constellation.points()
  states: {}
- name: digital_constellation_decoder_cb_20
  id: digital_constellation_decoder_cb
  parameters:
    comment: nearest constellation point ...
    constellation: constellation
  states: {}
- name: digital_constellation_modulator_12
  id: digital_constellation_modulator
  parameters:
    comment: RRC-shaped QPSK, unit symbol energy
    constellation: constellation
    differential: 'False'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_18
  id: digital_costas_loop_cc
  parameters:
    comment: carrier phase recovery (Lesson 19)
    order: constellation.arity()
    w: 2*math.pi/100
  states: {}
- name: digital_symbol_sync_xx_17
  id: digital_symbol_sync_xx
  parameters:
    comment: matched filter + timing recovery (Lesson 18)
    constellation: constellation
    damping: '1.0'
    loop_bw: '0.02'
    max_dev: '0.1'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rcc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: ted_gain
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: import_8
  id: import
  parameters:
    imports: |-
      import math
      from gnuradio import gr
      from gnuradio.filter import firdes
  states: {}
- name: qtgui_const_sink_x_19
  id: qtgui_const_sink_x
  parameters:
    label1: after Costas loop
    name: '"Received symbols"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_15
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    label1: after channel
    name: '"Received spectrum"'
    type: complex
  states: {}
- name: qtgui_number_sink_26
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: SNR
    max: '40'
    min: '0'
    name: '"Es/N0 from the error vector"'
    type: float
    unit1: dB
  states: {}
- name: qtgui_time_sink_x_28
  id: qtgui_time_sink_x
  parameters:
    label1: I
    label2: Q
    name: '"Symbols in time"'
    size: '200'
    srate: samp_rate/sps
    type: complex
  states: {}

connections:
- [analog_agc_xx_16, '0', digital_symbol_sync_xx_17, '0']
- [analog_random_source_x_11, '0', digital_constellation_modulator_12, '0']
- [blocks_complex_to_mag_squared_23, '0', blocks_moving_average_xx_24, '0']
- [blocks_moving_average_xx_24, '0', blocks_nlog10_ff_25, '0']
- [blocks_multiply_const_vxx_27, '0', blocks_sub_xx_22, '1']
- [blocks_nlog10_ff_25, '0', qtgui_number_sink_26, '0']
- [blocks_sub_xx_22, '0', blocks_complex_to_mag_squared_23, '0']
- [blocks_throttle2_13, '0', channels_channel_model_14, '0']
- [channels_channel_model_14, '0', analog_agc_xx_16, '0']
- [channels_channel_model_14, '0', qtgui_freq_sink_x_15, '0']
- [digital_chunks_to_symbols_xx_21, '0', blocks_multiply_const_vxx_27, '0']
- [digital_constellation_decoder_cb_20, '0', digital_chunks_to_symbols_xx_21, '0']
- [digital_constellation_modulator_12, '0', blocks_throttle2_13, '0']
- [digital_costas_loop_cc_18, '0', blocks_sub_xx_22, '0']
- [digital_costas_loop_cc_18, '0', digital_constellation_decoder_cb_20, '0']
- [digital_costas_loop_cc_18, '0', qtgui_const_sink_x_19, '0']
- [digital_costas_loop_cc_18, '0', qtgui_time_sink_x_28, '0']
- [digital_symbol_sync_xx_17, '0', digital_costas_loop_cc_18, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
