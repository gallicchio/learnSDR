options:
  parameters:
    author: Claude (Oct 2026), in the style of the learnSDR lessons
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson28_Multipath_Equalizer
    output_language: python
    title: Multipath and a simple adaptive equalizer (simulation)
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    comment: RRC excess bandwidth
    value: '0.5'
  states: {}
- name: cma
  id: variable_adaptive_algorithm
  parameters:
    comment: |-
      Constant Modulus Algorithm: adjust the taps so that
      |output| is always 1 (true for PSK). Needs no training data.
    cons: constellation
    modulus: '1'
    step_size: '0.002'
    type: cma
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: echo_amplitude
  id: variable_qtgui_range
  parameters:
    comment: |-
      relative amplitude of the second path (the echo).
      Start at 0, then raise it and watch the constellations
    start: '0'
    step: '0.01'
    stop: '0.9'
    value: '0.0'
  states: {}
- name: echo_delay
  id: variable_qtgui_range
  parameters:
    comment: |-
      delay of the echo in samples (sps = 8 samples per symbol,
      so 6 samples is 3/4 of a symbol)
    start: '0'
    step: '1'
    stop: '24'
    value: '6'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.05'
  states: {}
- name: rcc_taps
  id: variable
  parameters:
    comment: matched-filter prototype for the Symbol Sync
    value: firdes.root_raised_cosine(nfilts, nfilts*samp_rate, samp_rate/sps, alpha, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: samples per symbol
    value: '8'
  states: {}
- name: ted_gain
  id: variable
  parameters:
    comment: see Lesson 18
    value: 1.1*alpha/sps
  states: {}
- name: analog_agc_xx_21
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_random_source_x_13
  id: analog_random_source_x
  parameters:
    comment: random bytes
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_18
  id: blocks_add_xx
  parameters:
    comment: direct path + echo
    type: complex
  states: {}
- name: blocks_delay_16
  id: blocks_delay
  parameters:
    comment: the echo arrives late ...
    delay: echo_delay
    type: complex
  states: {}
- name: blocks_keep_one_in_n_23
  id: blocks_keep_one_in_n
  parameters:
    comment: just take one of the two samples per symbol
    n: '2'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_17
  id: blocks_multiply_const_vxx
  parameters:
    comment: ... and weaker (you could also give it a phase)
    const: echo_amplitude
    type: complex
  states: {}
- name: blocks_throttle2_15
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_19
  id: channels_channel_model
  parameters:
    comment: a little noise
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: '[1.0]'
  states: {}
- name: digital_constellation_modulator_14
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'False'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_24
  id: digital_costas_loop_cc
  parameters:
    order: constellation.arity()
    w: 2*math.pi/100
  states: {}
- name: digital_costas_loop_cc_27
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      the equalizer leaves an arbitrary rotation;
      the Costas loop removes it
    order: constellation.arity()
    w: 2*math.pi/100
  states: {}
- name: digital_linear_equalizer_26
  id: digital_linear_equalizer
  parameters:
    alg: cma
    comment: |-
      11-tap FIR filter whose taps are adjusted
      continuously by the CMA; input at 2 samples
      per symbol, output 1 per symbol
    num_taps: '11'
    sps: '2'
    training_sequence: '[]'
    training_start_tag: '""'
  states: {}
- name: digital_symbol_sync_xx_22
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      matched filter + timing recovery, but now
      2 output samples per symbol for the equalizer
    constellation: constellation
    damping: '1.0'
    loop_bw: '0.02'
    max_dev: '0.1'
    nfilters: nfilts
    osps: '2'
    pfb_mf_taps: rcc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: ted_gain
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: import_8
  id: import
  parameters:
    imports: |-
      import math
      from gnuradio import gr
      from gnuradio.filter import firdes
  states: {}
- name: qtgui_const_sink_x_25
  id: qtgui_const_sink_x
  parameters:
    label1: after Costas loop
    name: '"Without equalizer"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_28
  id: qtgui_const_sink_x
  parameters:
    label1: after equalizer and Costas loop
    name: '"With CMA equalizer"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_29
  id: qtgui_eye_sink_x
  parameters:
    comment: 'eye diagram before the equalizer: watch it close as the echo grows'
    label1: I
    label2: Q
    samp_per_symbol: '2'
    size: '1024'
    srate: 2*samp_rate/sps
    type: complex
  states: {}
- name: qtgui_freq_sink_x_20
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: |-
      the echo puts ripples in the spectrum:
      nulls every 1/(echo delay)
    fc: '0'
    fftsize: '2048'
    label1: after the two-path channel
    name: '"Received spectrum"'
    type: complex
  states: {}

connections:
- [analog_agc_xx_21, '0', digital_symbol_sync_xx_22, '0']
- [analog_random_source_x_13, '0', digital_constellation_modulator_14, '0']
- [blocks_add_xx_18, '0', channels_channel_model_19, '0']
- [blocks_delay_16, '0', blocks_multiply_const_vxx_17, '0']
- [blocks_keep_one_in_n_23, '0', digital_costas_loop_cc_24, '0']
- [blocks_multiply_const_vxx_17, '0', blocks_add_xx_18, '1']
- [blocks_throttle2_15, '0', blocks_add_xx_18, '0']
- [blocks_throttle2_15, '0', blocks_delay_16, '0']
- [channels_channel_model_19, '0', analog_agc_xx_21, '0']
- [channels_channel_model_19, '0', qtgui_freq_sink_x_20, '0']
- [digital_constellation_modulator_14, '0', blocks_throttle2_15, '0']
- [digital_costas_loop_cc_24, '0', qtgui_const_sink_x_25, '0']
- [digital_costas_loop_cc_27, '0', qtgui_const_sink_x_28, '0']
- [digital_linear_equalizer_26, '0', digital_costas_loop_cc_27, '0']
- [digital_symbol_sync_xx_22, '0', blocks_keep_one_in_n_23, '0']
- [digital_symbol_sync_xx_22, '0', digital_linear_equalizer_26, '0']
- [digital_symbol_sync_xx_22, '0', qtgui_eye_sink_x_29, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
