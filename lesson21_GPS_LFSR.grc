options:
  parameters:
    author: jason
    generate_options: qt_gui
    id: GPS_LFSR
    output_language: python
    title: GPS_LFSR
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1023e3
  states: {}
- name: vector_size
  id: variable
  parameters:
    value: 2**10-1
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_1_0_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: offset the plot
    const: '2'
    type: byte
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1_0_3
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vector_size
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_1
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vector_size
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/vector_size]*vector_size'
    type: complex
    vlen: vector_size
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/vector_size]*vector_size'
    type: complex
    vlen: vector_size
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_1_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_map_bb_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_map_bb_0_0_3
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_scrambler_bb_1_0
  id: digital_scrambler_bb
  parameters:
    comment: |-
      G1 LFSR:
      x^10+x^3+1
      For the scrambler,
      length really means length-1
      GPS documentation's definition 
      of the bits is the opposite order
    len: 10-1
    mask: 2**(10-10) + 2**(10-3)
    seed: 2**10-1
  states: {}
- name: digital_scrambler_bb_1_0_0
  id: digital_scrambler_bb
  parameters:
    comment: |-
      G2 LFSR: 
      x^10+x^9+x^8+x^6+x^3+x^2+1
    len: 10-1
    mask: 2**(10-10) + 2**(10-9) + 2**(10-8) + 2**(10-6) + 2**(10-3) + 2**(10-2)
    seed: 2**10-1
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_0_0_1
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_1_1
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_1_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_1_0_1
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (0,0)
    label1: One Cycle of G1 LFSR
    label2: One Cycle of G2 LFSR
    marker1: '0'
    marker2: '0'
    nconnections: '2'
    size: '1023'
    srate: '1'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (1,0)
    label1: FFT auto corr re of G1
    label2: FFT auto corr im of G1
    marker1: '0'
    marker2: '0'
    size: vector_size
    srate: '1'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (2,0)
    label1: FFT cross corr re between G1 and G2
    label2: FFT cross corr im between G1 and G2
    marker1: '0'
    marker2: '0'
    size: vector_size
    srate: '1'
    type: complex
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: G2
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: G1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: G1
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: G1
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: G1
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: G2
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [analog_const_source_x_1_0, '0', blocks_float_to_complex_0_0, '1']
- [analog_const_source_x_1_0, '0', blocks_float_to_complex_1_0, '1']
- [analog_const_source_x_1_0_1, '0', blocks_float_to_complex_0_0_1, '1']
- [analog_const_source_x_1_0_1, '0', blocks_float_to_complex_1_0_1, '1']
- [blocks_add_const_vxx_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0_0_0_0_0_1_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_char_to_float_0_0_0_0_0_1_0_0, '0', blocks_float_to_complex_1_0, '0']
- [blocks_char_to_float_0_0_0_0_0_1_0_0_0, '0', blocks_float_to_complex_1_0_1, '0']
- [blocks_char_to_float_0_0_0_0_0_1_0_3, '0', blocks_float_to_complex_0_0_1, '0']
- [blocks_float_to_complex_0_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [blocks_float_to_complex_0_0_1, '0', blocks_stream_to_vector_0_0_0_0_1, '0']
- [blocks_float_to_complex_1_0, '0', blocks_stream_to_vector_0_0_1, '0']
- [blocks_float_to_complex_1_0_1, '0', blocks_stream_to_vector_0_0_1_1, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', fft_vxx_1_0, '0']
- [blocks_multiply_conjugate_cc_0_0_1, '0', fft_vxx_1_0_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_vector_to_stream_0_0_1, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_0_0_0_0_1, '0', fft_vxx_0_1_1, '0']
- [blocks_stream_to_vector_0_0_1, '0', fft_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_0_1_1, '0', fft_vxx_0_0_0_1, '0']
- [blocks_throttle_0, '0', digital_scrambler_bb_1_0, '0']
- [blocks_throttle_0, '0', digital_scrambler_bb_1_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_1_1, '0']
- [blocks_vector_to_stream_0_0_1, '0', qtgui_time_sink_x_1_1_1, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_0_0_0_0_0_1_0, '0']
- [digital_map_bb_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_1_0_0, '0']
- [digital_map_bb_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_1_0_0_0, '0']
- [digital_map_bb_0_0_3, '0', blocks_char_to_float_0_0_0_0_0_1_0_3, '0']
- [digital_scrambler_bb_1_0, '0', blocks_add_const_vxx_0, '0']
- [digital_scrambler_bb_1_0, '0', virtual_sink_0_0_0_0, '0']
- [digital_scrambler_bb_1_0_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [digital_scrambler_bb_1_0_0, '0', virtual_sink_0_0_0, '0']
- [fft_vxx_0_0_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [fft_vxx_0_0_0_1, '0', blocks_multiply_conjugate_cc_0_0_1, '1']
- [fft_vxx_0_1, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [fft_vxx_0_1_1, '0', blocks_multiply_conjugate_cc_0_0_1, '0']
- [fft_vxx_1_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [fft_vxx_1_0_1, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [virtual_source_0_0, '0', digital_map_bb_0_0, '0']
- [virtual_source_0_0_0, '0', digital_map_bb_0_0_3, '0']
- [virtual_source_0_1, '0', digital_map_bb_0_0_0, '0']
- [virtual_source_0_1_0, '0', digital_map_bb_0_0_0_0, '0']

metadata:
  file_format: 1
