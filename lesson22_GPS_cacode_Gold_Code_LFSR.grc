options:
  parameters:
    author: jason
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson22_GPS_cacode_Gold_Code_LFSR
    output_language: python
    title: GPS_cacode_Gold_Code_LFSR
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1023e3
  states: {}
- name: vector_size
  id: variable
  parameters:
    value: 2**10-1
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: byte
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_1_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_1_0_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: offset plot
    const: '6'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    comment: offset plot
    const: '4'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    comment: offset plot
    const: '2'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    comment: offset plot
    const: '0'
    type: byte
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1_0_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1_0_3
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0_1_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: '1'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    comment: '2'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    comment: '3'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    comment: '4'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    comment: '5'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    comment: '6'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    comment: '7'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    comment: '10'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    comment: '10'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_0_1
  id: blocks_delay
  parameters:
    comment: '7'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_1
  id: blocks_delay
  parameters:
    comment: '9'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_1_0
  id: blocks_delay
  parameters:
    comment: '9'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_0_2
  id: blocks_delay
  parameters:
    comment: '6'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_1
  id: blocks_delay
  parameters:
    comment: '8'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_1_0
  id: blocks_delay
  parameters:
    comment: '8'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_0_2
  id: blocks_delay
  parameters:
    comment: '5'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_0_1
  id: blocks_delay
  parameters:
    comment: '4'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_0_1
  id: blocks_delay
  parameters:
    comment: '3'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_0_1
  id: blocks_delay
  parameters:
    comment: '2'
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    comment: '1'
    delay: '1'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vector_size
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vector_size
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vector_size
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_1
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vector_size
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/vector_size]*vector_size'
    type: complex
    vlen: vector_size
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/vector_size]*vector_size'
    type: complex
    vlen: vector_size
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/vector_size]*vector_size'
    type: complex
    vlen: vector_size
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/vector_size]*vector_size'
    type: complex
    vlen: vector_size
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_1_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    comment: SV1 taps 2,6
    type: byte
  states: {}
- name: blocks_xor_xx_0_0
  id: blocks_xor_xx
  parameters:
    comment: SV2 taps 3,7
    type: byte
  states: {}
- name: blocks_xor_xx_1
  id: blocks_xor_xx
  parameters:
    comment: SV1 cacode
    type: byte
  states: {}
- name: blocks_xor_xx_1_0
  id: blocks_xor_xx
  parameters:
    comment: SV2 cacode
    type: byte
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_map_bb_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_map_bb_0_0_1
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_map_bb_0_0_2
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_map_bb_0_0_3
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_map_bb_0_1
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_scrambler_bb_1_0
  id: digital_scrambler_bb
  parameters:
    comment: |-
      G1 LFSR:
      x^10+x^3+1
      For the scrambler,
      length really means length-1
      GPS documentation's definition 
      of the bits is the opposite order
    len: 10-1
    mask: 2**(10-10) + 2**(10-3)
    seed: 2**10-1
  states: {}
- name: digital_scrambler_bb_1_0_0
  id: digital_scrambler_bb
  parameters:
    comment: |-
      G2 LFSR: 
      x^10+x^9+x^8+x^6+x^3+x^2+1
    len: 10-1
    mask: 2**(10-10) + 2**(10-9) + 2**(10-8) + 2**(10-6) + 2**(10-3) + 2**(10-2)
    seed: 2**10-1
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_0_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_0_0_1
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_1_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_1_1
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_1_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_1_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_1_0_1
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: gps_taps_note
  id: note
  parameters:
    comment: |-
      GPS C/A code: G2 taps for each satellite (IS-GPS-200, Table 3-Ia)
      C/A = G1[10] xor G2[t1] xor G2[t2]   (delay n = tap n)
      PRN 1: 2,6    PRN 2: 3,7    PRN 3: 4,8    PRN 4: 5,9
      PRN 5: 1,9    PRN 6: 2,10   PRN 7: 1,8    PRN 8: 2,9
      PRN 9: 3,10   PRN 10: 2,3   PRN 11: 3,4   PRN 12: 5,6
      PRN 13: 6,7   PRN 14: 7,8   PRN 15: 8,9   PRN 16: 9,10
      PRN 17: 1,4   PRN 18: 2,5   PRN 19: 3,6   PRN 20: 4,7
      PRN 21: 5,8   PRN 22: 6,9   PRN 23: 1,3   PRN 24: 4,6
      PRN 25: 5,7   PRN 26: 6,8   PRN 27: 7,9   PRN 28: 8,10
      PRN 29: 1,6   PRN 30: 2,7   PRN 31: 3,8   PRN 32: 4,9
      (All 32 verified against the IS-GPS-200 first-10-chip table, Oct 2026.)
    note: G2 taps for every GPS satellite
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (0,0)
    label1: One Cycle of G1 LFSR
    label2: One Cycle of G2 LFSR
    label3: Gold Code for SV1 (1023 chips)
    label4: Gold Code for SV2 (1023 chips)
    marker1: '0'
    marker2: '0'
    marker3: '0'
    marker4: '0'
    nconnections: '4'
    size: '1023'
    srate: '1'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (3,0)
    label1: FFT auto corr re of SV1's CA Gold Code
    label2: FFT auto corr im of SV1's CA Gold Code
    marker1: '0'
    marker2: '0'
    size: vector_size
    srate: '1'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (1,0)
    label1: FFT auto corr re of G1
    label2: FFT auto corr im of G1
    marker1: '0'
    marker2: '0'
    size: vector_size
    srate: '1'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (4,0)
    label1: FFT cross corr re between SV1 and SV2 CA codes
    label2: FFT cross corr im between SV1 and SV2 CA codes
    marker1: '0'
    marker2: '0'
    size: vector_size
    srate: '1'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (2,0)
    label1: FFT cross corr re between G1 and G2
    label2: FFT cross corr im between G1 and G2
    marker1: '0'
    marker2: '0'
    size: vector_size
    srate: '1'
    type: complex
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: G2
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: G1
  states: {}
- name: virtual_sink_0_0_0_2
  id: virtual_sink
  parameters:
    stream_id: SV1CA
  states: {}
- name: virtual_sink_0_0_0_2_0
  id: virtual_sink
  parameters:
    stream_id: SV2CA
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: SV1CA
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: G1
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: G1
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: G1
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: G2
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: SV1CA
  states: {}
- name: virtual_source_0_3
  id: virtual_source
  parameters:
    stream_id: SV2CA
  states: {}
- name: virtual_source_0_4
  id: virtual_source
  parameters:
    stream_id: SV1CA
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [analog_const_source_x_1, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_1, '0', blocks_float_to_complex_1, '1']
- [analog_const_source_x_1_0, '0', blocks_float_to_complex_0_0, '1']
- [analog_const_source_x_1_0, '0', blocks_float_to_complex_1_0, '1']
- [analog_const_source_x_1_0_0, '0', blocks_float_to_complex_0_0_0, '1']
- [analog_const_source_x_1_0_0, '0', blocks_float_to_complex_1_0_0, '1']
- [analog_const_source_x_1_0_1, '0', blocks_float_to_complex_0_0_1, '1']
- [analog_const_source_x_1_0_1, '0', blocks_float_to_complex_1_0_1, '1']
- [blocks_add_const_vxx_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', blocks_char_to_float_0_0_0_0_0, '0']
- [blocks_add_const_vxx_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0_0_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_char_to_float_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_char_to_float_0_0_0_0_0_1, '0', blocks_float_to_complex_1, '0']
- [blocks_char_to_float_0_0_0_0_0_1_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_char_to_float_0_0_0_0_0_1_0_0, '0', blocks_float_to_complex_1_0, '0']
- [blocks_char_to_float_0_0_0_0_0_1_0_0_0, '0', blocks_float_to_complex_1_0_1, '0']
- [blocks_char_to_float_0_0_0_0_0_1_0_1, '0', blocks_float_to_complex_0_0_0, '0']
- [blocks_char_to_float_0_0_0_0_0_1_0_2, '0', blocks_float_to_complex_1_0_0, '0']
- [blocks_char_to_float_0_0_0_0_0_1_0_3, '0', blocks_float_to_complex_0_0_1, '0']
- [blocks_char_to_float_0_0_0_0_0_1_1, '0', blocks_float_to_complex_0, '0']
- [blocks_delay_0, '0', blocks_delay_0_0, '0']
- [blocks_delay_0_0, '0', blocks_delay_0_0_0, '0']
- [blocks_delay_0_0, '0', blocks_xor_xx_0, '1']
- [blocks_delay_0_0_0, '0', blocks_delay_0_0_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_xor_xx_0_0, '1']
- [blocks_delay_0_0_0_0, '0', blocks_delay_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0, '0', blocks_delay_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0, '0', blocks_delay_0_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0, '0', blocks_xor_xx_0, '0']
- [blocks_delay_0_0_0_0_0_0_0, '0', blocks_delay_0_0_0_0_0_1, '0']
- [blocks_delay_0_0_0_0_0_0_0, '0', blocks_xor_xx_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_0, '0', virtual_sink_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_0_0, '0', blocks_xor_xx_1, '0']
- [blocks_delay_0_0_0_0_0_0_0_0_0, '0', blocks_xor_xx_1_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_0_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_0_1, '0', blocks_delay_0_0_0_0_0_1_0, '0']
- [blocks_delay_0_0_0_0_0_0_1, '0', blocks_delay_0_0_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_1_0, '0', blocks_delay_0_0_0_0_0_0_0_0_0, '0']
- [blocks_delay_0_0_0_0_0_0_2, '0', blocks_delay_0_0_0_0_0_0_0_1, '0']
- [blocks_delay_0_0_0_0_0_1, '0', blocks_delay_0_0_0_0_0_0_1, '0']
- [blocks_delay_0_0_0_0_0_1_0, '0', blocks_delay_0_0_0_0_0_0_1_0, '0']
- [blocks_delay_0_0_0_0_0_2, '0', blocks_delay_0_0_0_0_0_0_2, '0']
- [blocks_delay_0_0_0_0_1, '0', blocks_delay_0_0_0_0_0_2, '0']
- [blocks_delay_0_0_0_1, '0', blocks_delay_0_0_0_0_1, '0']
- [blocks_delay_0_0_1, '0', blocks_delay_0_0_0_1, '0']
- [blocks_delay_0_1, '0', blocks_delay_0_0_1, '0']
- [blocks_float_to_complex_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [blocks_float_to_complex_0_0_0, '0', blocks_stream_to_vector_0_0_0_0_0, '0']
- [blocks_float_to_complex_0_0_1, '0', blocks_stream_to_vector_0_0_0_0_1, '0']
- [blocks_float_to_complex_1, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_float_to_complex_1_0, '0', blocks_stream_to_vector_0_0_1, '0']
- [blocks_float_to_complex_1_0_0, '0', blocks_stream_to_vector_0_0_1_0, '0']
- [blocks_float_to_complex_1_0_1, '0', blocks_stream_to_vector_0_0_1_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_1, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', fft_vxx_1_0, '0']
- [blocks_multiply_conjugate_cc_0_0_0, '0', fft_vxx_1_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0_1, '0', fft_vxx_1_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_vector_to_stream_0_0_1, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_0_0_0_0_0, '0', fft_vxx_0_1_0, '0']
- [blocks_stream_to_vector_0_0_0_0_1, '0', fft_vxx_0_1_1, '0']
- [blocks_stream_to_vector_0_0_1, '0', fft_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_0_1_0, '0', fft_vxx_0_0_0_0, '0']
- [blocks_stream_to_vector_0_0_1_1, '0', fft_vxx_0_0_0_1, '0']
- [blocks_throttle_0, '0', digital_scrambler_bb_1_0, '0']
- [blocks_throttle_0, '0', digital_scrambler_bb_1_0_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_1_1, '0']
- [blocks_vector_to_stream_0_0_0, '0', qtgui_time_sink_x_1_1_0, '0']
- [blocks_vector_to_stream_0_0_1, '0', qtgui_time_sink_x_1_1_1, '0']
- [blocks_xor_xx_0, '0', blocks_xor_xx_1, '1']
- [blocks_xor_xx_0_0, '0', blocks_xor_xx_1_0, '1']
- [blocks_xor_xx_1, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_xor_xx_1, '0', virtual_sink_0_0_0_2, '0']
- [blocks_xor_xx_1_0, '0', blocks_add_const_vxx_0_0_0_0, '0']
- [blocks_xor_xx_1_0, '0', virtual_sink_0_0_0_2_0, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0_0_0_0_0_1, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_0_0_0_0_0_1_0, '0']
- [digital_map_bb_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_1_0_0, '0']
- [digital_map_bb_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0_1_0_0_0, '0']
- [digital_map_bb_0_0_1, '0', blocks_char_to_float_0_0_0_0_0_1_0_1, '0']
- [digital_map_bb_0_0_2, '0', blocks_char_to_float_0_0_0_0_0_1_0_2, '0']
- [digital_map_bb_0_0_3, '0', blocks_char_to_float_0_0_0_0_0_1_0_3, '0']
- [digital_map_bb_0_1, '0', blocks_char_to_float_0_0_0_0_0_1_1, '0']
- [digital_scrambler_bb_1_0, '0', blocks_delay_0_1, '0']
- [digital_scrambler_bb_1_0_0, '0', blocks_delay_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_0_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [fft_vxx_0_0_0_0, '0', blocks_multiply_conjugate_cc_0_0_0, '1']
- [fft_vxx_0_0_0_1, '0', blocks_multiply_conjugate_cc_0_0_1, '1']
- [fft_vxx_0_1, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [fft_vxx_0_1_0, '0', blocks_multiply_conjugate_cc_0_0_0, '0']
- [fft_vxx_0_1_1, '0', blocks_multiply_conjugate_cc_0_0_1, '0']
- [fft_vxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [fft_vxx_1_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [fft_vxx_1_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [fft_vxx_1_0_1, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [virtual_source_0, '0', digital_map_bb_0, '0']
- [virtual_source_0_0, '0', digital_map_bb_0_0, '0']
- [virtual_source_0_0_0, '0', digital_map_bb_0_0_3, '0']
- [virtual_source_0_1, '0', digital_map_bb_0_0_0, '0']
- [virtual_source_0_1_0, '0', digital_map_bb_0_0_0_0, '0']
- [virtual_source_0_2, '0', digital_map_bb_0_0_1, '0']
- [virtual_source_0_3, '0', digital_map_bb_0_0_2, '0']
- [virtual_source_0_4, '0', digital_map_bb_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
