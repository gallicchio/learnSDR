options:
  parameters:
    generate_options: qt_gui
    id: Pluto_Doppler_RADAR
    output_language: python
    title: Pluto_Doppler_RADAR
  states: {}

blocks:
- name: LO_freq
  id: variable
  parameters:
    value: '2400000000'
  states: {state: disabled}
- name: LO_freq
  id: variable
  parameters:
    value: '3800000000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '40000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: LO_freq
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    uri: 192.168.2.1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    label1: raw
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: raw re
    label2: raw im
    size: 1024*8
    srate: samp_rate
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
