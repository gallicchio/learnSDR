options:
  parameters:
    author: jason
    generate_options: qt_gui
    id: pluto433HAM
    output_language: python
    title: pluto433HAM
  states: {}

blocks:
- name: freqMHz
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '420'
    step: '0.001'
    stop: '450'
    value: '433'
  states: {state: disabled}
- name: freqMHz
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '88.1'
    step: '.2'
    stop: '108.1'
    value: '101.3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2084000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: int(freqMHz*1e6)
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
