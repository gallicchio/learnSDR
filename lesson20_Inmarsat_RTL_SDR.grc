options:
  parameters:
    author: jason
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson20_Inmarsat_RTL_SDR
    output_language: python
    title: GPS_RTL_SDR
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    comment: |-
      Can't change alpha in real time
      for Consteallation Modulator
    value: '0.98'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0,1,2,3]'
    type: calcdist
  states: {state: disabled}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    sym_map: '[0,1,2,3]'
    type: bpsk
  states: {}
- name: costas_loop_bandwidth_in_cycles_per_sample
  id: variable_qtgui_range
  parameters:
    gui_hint: 21,0
    start: '0.0001'
    step: '0.0001'
    stop: '0.2'
    value: '.01'
  states: {}
- name: fine_tune
  id: variable_qtgui_range
  parameters:
    start: '-10e3'
    step: '400'
    stop: 10e3
    value: '200'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: offset_tune
  id: variable_qtgui_range
  parameters:
    start: '-10e3'
    step: '400'
    stop: 10e3
    value: 10e3
  states: {}
- name: output_sps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rcc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: alpha
    comment: |-
      Gain: nfilts
      Sample Rate: nfilts*samp_rate
      Symbol Rate: samp_rate/sps
      Excess BW: alpha
      Num Taps: 11*sps*nfilts
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '80'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: 'Inmarsat-C: 1200 symbols per second'
    value: '1200'
  states: {}
- name: ted_gain
  id: variable
  parameters:
    comment: |-
      Expected TED gain = slope of the timing-error S-curve, in error units per SAMPLE of timing offset.
      For the Signal-times-Slope TED with root-raised-cosine pulses it is about
          1.1 * alpha * (AGC reference)^2 / sps        (sps >= 8; about 0.8*alpha/sps at sps = 4)
      measured by simulation (Oct 2026). The AGC reference here is 1.
      GNU Radio's default of 1.0 is ~30x too big for this flowgraph, which makes the loop slow and badly under-damped.
    value: 1.1*alpha/sps
  states: {}
- name: analog_agc_xx_1
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-2'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset_tune+fine_tune
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      skip one second of samples
      to allow FLL to sync
    num_items: int(samp_rate/int(samp_rate/symbol_rate/sps))
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: constellation.arity()
    w: 2*math.pi*costas_loop_bandwidth_in_cycles_per_sample
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    comment: |-
      Samples Per Symbol: sps
      Filter Rolloff Factor: alpha
      Prototype Filter Size: sps*2+1
      Loop Bandwidth: 2*math.pi/sps/100
    filter_size: sps*2+1
    improved_loop_filter: 'False'
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: 2*math.pi/sps/100
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[1,-1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      Filterbank Arms: nfilts
      PFB MF Taps: rcc_taps
      Changed Maximum Deviation to 0.1 because 
      the clocks aren't more off than 0.1 samples per symbol
    constellation: constellation
    damping: '1.0'
    loop_bw: '0.02'
    max_dev: '0.1'
    nfilters: nfilts
    osps: output_sps
    pfb_mf_taps: rcc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: ted_gain
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: int(samp_rate/symbol_rate/sps)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: makes most sense if "Output Samples/Symbol" is 1
    gui_hint: 13,0
    label1: Symbol Sync
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: makes most sense if "Output Samples/Symbol" is 1
    gui_hint: 17,0
    label1: after Symbol Sync
    label2: after Costas
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    comment: changed labels
    gui_hint: 10,0
    label1: Eye Diagram for Receive AGC and FLL Re
    label2: Eye Diagram for Receive AGC and FLL  Im
    marker1: '0'
    marker2: '0'
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_eye_sink_x_0_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: 12,0
    label1: Eye Diagram for Receive Symbol Sync Re
    label2: Eye Diagram for Receive Symbol Sync  Im
    marker1: '0'
    marker2: '0'
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate/sps*output_sps
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_eye_sink_x_0_0_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: 16,0
    label1: Eye Diagram after Costas Re
    label2: Eye Diagram after Costas  Im
    marker1: '0'
    marker2: '0'
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate/sps*output_sps
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: '200'
    nrows: '256'
    samp_rate: symbol_rate
    type: byte
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 9,0
    label1: Receive Tuned AGC and FLL Re
    label2: Receive Tuned AGC and FLL Im
    size: 1024*8
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 11,0
    label1: Receive Symbol Sync Re
    label2: Receive Symbol Sync Im
    size: 10*sps
    srate: samp_rate/sps*output_sps
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 18,0
    label1: Receive after Costas Re
    label2: Receive after Costas Im
    marker1: '0'
    marker2: '0'
    size: '100'
    srate: samp_rate/sps*output_sps
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: RTL-SDR raw Re
    label2: RTL-SDR raw Im
    size: int(samp_rate/1000)
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 14,0
    label1: Sync error
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 15,0
    label1: Sync T_inst
    label2: Sync T_avg
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: sps*1.01
    ymin: sps*0.99
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.5'
    gui_hint: 19,0
    label1: Costas error
    label2: Costas frequency [rad/samp]
    nconnections: '2'
    size: '10000'
    srate: samp_rate/sps*output_sps
    type: float
    width2: '2'
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_1_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 20,0
    label1: Costas phase
    size: '10000'
    srate: samp_rate/sps*output_sps
    type: float
    ymax: '7'
    ymin: '-7'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/100
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl,bias=1"'
    bb_gain0: '20'
    comment: |-
      Add "rtl,bias=1" to 
      Device Arguments arguments 
      to turn on the bias T
      Tune to 1541.450 MHz for Inmarsat STD-C NCS.
      1200 bps
    freq0: 1541.450e6 + offset_tune
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_1, '0', digital_fll_band_edge_cc_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_skiphead_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '1']
- [digital_costas_loop_cc_0, '0', qtgui_eye_sink_x_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '0']
- [digital_costas_loop_cc_0, '1', qtgui_time_sink_x_1_1, '1']
- [digital_costas_loop_cc_0, '2', qtgui_time_sink_x_1_1_0, '0']
- [digital_costas_loop_cc_0, '3', qtgui_time_sink_x_1_1, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_map_bb_0, '0', qtgui_time_raster_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_eye_sink_x_0_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [digital_symbol_sync_xx_0, '1', qtgui_time_sink_x_1, '0']
- [digital_symbol_sync_xx_0, '2', qtgui_time_sink_x_1_0, '0']
- [digital_symbol_sync_xx_0, '3', qtgui_time_sink_x_1_0, '1']
- [low_pass_filter_0, '0', analog_agc_xx_1, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_eye_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
