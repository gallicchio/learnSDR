options:
  parameters:
    author: Claude (Oct 2026), in the style of the learnSDR lessons
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson35_Correlation
    output_language: python
    title: 'Correlation: sliding, multiplying and summing (simulation)'
  states: {}

blocks:
- name: barker
  id: variable
  parameters:
    comment: |-
      Barker-13 code: its autocorrelation sidelobes are all +/-1
      (peak 13), the best any 13-chip sequence can do
    value: '[1,1,1,1,1,-1,-1,1,1,-1,1,-1,1]'
  states: {}
- name: code
  id: variable
  parameters:
    value: '[barker, ones, rand13][int(which)]'
  states: {}
- name: gap
  id: variable
  parameters:
    comment: silence between codes, so one code = 50 samples
    value: '[0]*37'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    comment: noise added before the correlators
    start: '0'
    step: '0.05'
    stop: '3'
    value: '0.3'
  states: {}
- name: ones
  id: variable
  parameters:
    comment: 'a "code" of 13 ones: a boxcar'
    value: '[1]*13'
  states: {}
- name: rand13
  id: variable
  parameters:
    comment: a random 13-chip sequence, for comparison
    value: '[1,-1,1,1,-1,-1,-1,1,-1,1,1,1,-1]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: which
  id: variable_qtgui_range
  parameters:
    comment: 0 = Barker, 1 = all ones, 2 = random 13
    start: '0'
    step: '1'
    stop: '2'
    value: '0'
  states: {}
- name: analog_noise_source_x_12
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_16
  id: analog_noise_source_x
  parameters:
    amp: '1'
    comment: pure noise ...
    noise_type: analog.GR_GAUSSIAN
    seed: '1'
    type: float
  states: {}
- name: blocks_add_xx_13
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_11
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_17
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_10
  id: blocks_vector_source_x
  parameters:
    comment: the code, over and over, with gaps
    repeat: 'True'
    type: float
    vector: code + gap
  states: {}
- name: fir_filter_xxx_14
  id: fir_filter_xxx
  parameters:
    comment: |-
      correlator = FIR filter with the time-reversed code as taps:
      at each output it slides the code along the input,
      multiplies, and sums (Lesson 22 did this with FFTs)
    decim: '1'
    taps: code[::-1]
    type: fff
  states: {}
- name: fir_filter_xxx_18
  id: fir_filter_xxx
  parameters:
    comment: |-
      ... correlated with the code: no peaks, just noise
      of RMS sqrt(13) x noise. Noise does not "look like" the code;
      this is why correlation finds weak signals (GPS, Lesson 23)
    decim: '1'
    taps: code[::-1]
    type: fff
  states: {}
- name: import_2
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_15
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      peak of 13 once per code; what happens next to the
      peak is the "sidelobe" structure, and it is what makes
      Barker codes special. Try the three codes.
    label1: code + noise
    label2: correlation
    name: '"Input and correlator output"'
    nconnections: '2'
    size: '400'
    srate: samp_rate
    type: float
    ymax: '15'
    ymin: '-15'
  states: {}
- name: qtgui_time_sink_x_19
  id: qtgui_time_sink_x
  parameters:
    label1: correlation of noise with the code
    name: '"Noise alone through the correlator"'
    size: '400'
    srate: samp_rate
    type: float
    ymax: '15'
    ymin: '-15'
  states: {}

connections:
- [analog_noise_source_x_12, '0', blocks_add_xx_13, '1']
- [analog_noise_source_x_16, '0', blocks_throttle2_17, '0']
- [blocks_add_xx_13, '0', fir_filter_xxx_14, '0']
- [blocks_add_xx_13, '0', qtgui_time_sink_x_15, '0']
- [blocks_throttle2_11, '0', blocks_add_xx_13, '0']
- [blocks_throttle2_17, '0', fir_filter_xxx_18, '0']
- [blocks_vector_source_x_10, '0', blocks_throttle2_11, '0']
- [fir_filter_xxx_14, '0', qtgui_time_sink_x_15, '1']
- [fir_filter_xxx_18, '0', qtgui_time_sink_x_19, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
