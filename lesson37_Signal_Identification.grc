options:
  parameters:
    author: Claude (Oct 2026), in the style of the learnSDR lessons
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson37_Signal_Identification
    output_language: python
    title: What is that signal? Symbol rate and carrier from nonlinearities (simulation)
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    comment: try bpsk, qpsk, 8psk
    precision: '8'
    type: qpsk
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: the "unknown" carrier offset (Hz)
    start: '-100e3'
    step: 1e3
    stop: 100e3
    value: 20e3
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.05'
    stop: '2'
    value: '0.3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: the "unknown" symbol rate is samp_rate/sps = 100 kBd
    value: '10'
  states: {}
- name: analog_random_source_x_8
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_complex_to_mag_squared_13
  id: blocks_complex_to_mag_squared
  parameters:
    comment: |-
      |x|^2: the envelope. RRC pulses make the envelope
      breathe once per symbol ...
  states: {}
- name: blocks_multiply_xx_15
  id: blocks_multiply_xx
  parameters:
    comment: |-
      x^2: for BPSK the +/-1 modulation disappears
      and a line appears at 2 x carrier offset
    type: complex
  states: {}
- name: blocks_multiply_xx_17
  id: blocks_multiply_xx
  parameters:
    comment: |-
      x^4: QPSK's four phases times 4 are all the same,
      so a line appears at 4 x carrier offset
    type: complex
  states: {}
- name: blocks_throttle2_10
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_11
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: freq_offset/samp_rate
    noise_voltage: noise_voltage
    seed: '0'
    taps: '[1.0]'
  states: {}
- name: digital_constellation_modulator_9
  id: digital_constellation_modulator
  parameters:
    comment: the signal we pretend not to know
    constellation: constellation
    differential: 'False'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: import_4
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_12
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    comment: |-
      a hump: you can read off the bandwidth and roughly
      the center, but neither the symbol rate nor the carrier
      exactly, and no idea which modulation
    fc: '0'
    fftsize: '4096'
    label1: '|X(f)|^2'
    name: '"1. The signal itself"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_14
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    comment: |-
      ... so there is a spectral line at exactly the symbol
      rate (100 kHz), independent of modulation and carrier.
      This is how a receiver that knows nothing recovers timing.
    fc: '0'
    fftsize: '4096'
    label1: '|x|^2'
    name: '"2. Spectrum of |x|^2: a line at the SYMBOL RATE"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_16
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    comment: 'BPSK: a line at 2*freq_offset. QPSK: nothing yet'
    fc: '0'
    fftsize: '4096'
    label1: x^2
    name: '"3. Spectrum of x^2"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_18
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    comment: |-
      QPSK: a line at 4*freq_offset (80 kHz here).
      This is also what the Costas loop exploits (Lesson 19),
      and why it has a 4-fold ambiguity
    fc: '0'
    fftsize: '4096'
    label1: x^4
    name: '"4. Spectrum of x^4"'
    type: complex
  states: {}

connections:
- [analog_random_source_x_8, '0', digital_constellation_modulator_9, '0']
- [blocks_complex_to_mag_squared_13, '0', qtgui_freq_sink_x_14, '0']
- [blocks_multiply_xx_15, '0', blocks_multiply_xx_17, '0']
- [blocks_multiply_xx_15, '0', blocks_multiply_xx_17, '1']
- [blocks_multiply_xx_15, '0', qtgui_freq_sink_x_16, '0']
- [blocks_multiply_xx_17, '0', qtgui_freq_sink_x_18, '0']
- [blocks_throttle2_10, '0', channels_channel_model_11, '0']
- [channels_channel_model_11, '0', blocks_complex_to_mag_squared_13, '0']
- [channels_channel_model_11, '0', blocks_multiply_xx_15, '0']
- [channels_channel_model_11, '0', blocks_multiply_xx_15, '1']
- [channels_channel_model_11, '0', qtgui_freq_sink_x_12, '0']
- [digital_constellation_modulator_9, '0', blocks_throttle2_10, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
