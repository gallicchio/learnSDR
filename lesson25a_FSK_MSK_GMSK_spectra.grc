options:
  parameters:
    author: Claude (Oct 2026), in the style of the learnSDR lessons
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson25a_FSK_MSK_GMSK_spectra
    output_language: python
    title: FSK, MSK, GMSK and QPSK spectra (simulation)
  states: {}

blocks:
- name: bt
  id: variable
  parameters:
    comment: Gaussian filter bandwidth x bit time (GSM uses 0.3)
    value: '0.3'
  states: {}
- name: gauss_taps
  id: variable
  parameters:
    comment: Gaussian pulse-shaping filter, 4 bits long
    value: firdes.gaussian(1, sps, bt, 4*sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: samples per bit
    value: '16'
  states: {}
- name: analog_frequency_modulator_fc_13
  id: analog_frequency_modulator_fc
  parameters:
    comment: |-
      2-FSK, modulation index h = 1:
      the two tones are 1 bit-rate apart.
      phase advances by pi*h per bit
    sensitivity: math.pi*1.0/sps
  states: {}
- name: analog_frequency_modulator_fc_14
  id: analog_frequency_modulator_fc
  parameters:
    comment: |-
      MSK = FSK with h = 0.5, the smallest h that
      keeps the two tones orthogonal
    sensitivity: math.pi*0.5/sps
  states: {}
- name: analog_frequency_modulator_fc_16
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: math.pi*0.5/sps
  states: {}
- name: analog_random_source_x_17
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_6
  id: analog_random_source_x
  parameters:
    comment: random bytes
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_const_vxx_9
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_char_to_float_8
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_10
  id: blocks_multiply_const_vxx
  parameters:
    comment: bits 0/1 -> -1/+1
    const: '2'
    type: float
  states: {}
- name: blocks_repeat_11
  id: blocks_repeat
  parameters:
    comment: rectangular bit pulses
    interp: sps
    type: float
  states: {}
- name: blocks_throttle2_12
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_19
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_7
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: one bit per byte
    k: '8'
  states: {}
- name: digital_constellation_modulator_18
  id: digital_constellation_modulator
  parameters:
    comment: |-
      QPSK at the same BIT rate:
      2 bits per symbol, so 2*sps samples per symbol
    constellation: digital.constellation_qpsk().base()
    differential: 'False'
    excess_bw: '0.5'
    samples_per_symbol: 2*sps
  states: {}
- name: fir_filter_xxx_15
  id: fir_filter_xxx
  parameters:
    comment: |-
      GMSK: smooth the bit pulses with a Gaussian
      filter before the FM, so the frequency
      changes gently
    decim: '1'
    taps: gauss_taps
    type: fff
  states: {}
- name: import_4
  id: import
  parameters:
    imports: |-
      import math
      from gnuradio.filter import firdes
  states: {}
- name: qtgui_freq_sink_x_20
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: |-
      FSK is wide; MSK is narrower; GMSK has no sidelobes;
      QPSK (with 2 bits per symbol) is the narrowest
    fc: '0'
    fftsize: '4096'
    label1: 2-FSK (h=1)
    label2: MSK (h=0.5)
    label3: GMSK (h=0.5, BT=0.3)
    label4: QPSK (RRC, alpha=0.5)
    name: '"Spectra at the same bit rate"'
    nconnections: '4'
    type: complex
  states: {}
- name: qtgui_time_sink_x_21
  id: qtgui_time_sink_x
  parameters:
    label1: rectangular bits (FSK, MSK)
    label2: Gaussian-filtered bits (GMSK)
    name: '"Instantaneous frequency (bits)"'
    nconnections: '2'
    size: '512'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_frequency_modulator_fc_13, '0', qtgui_freq_sink_x_20, '0']
- [analog_frequency_modulator_fc_14, '0', qtgui_freq_sink_x_20, '1']
- [analog_frequency_modulator_fc_16, '0', qtgui_freq_sink_x_20, '2']
- [analog_random_source_x_17, '0', digital_constellation_modulator_18, '0']
- [analog_random_source_x_6, '0', blocks_unpack_k_bits_bb_7, '0']
- [blocks_add_const_vxx_9, '0', blocks_multiply_const_vxx_10, '0']
- [blocks_char_to_float_8, '0', blocks_add_const_vxx_9, '0']
- [blocks_multiply_const_vxx_10, '0', blocks_repeat_11, '0']
- [blocks_repeat_11, '0', blocks_throttle2_12, '0']
- [blocks_throttle2_12, '0', analog_frequency_modulator_fc_13, '0']
- [blocks_throttle2_12, '0', analog_frequency_modulator_fc_14, '0']
- [blocks_throttle2_12, '0', fir_filter_xxx_15, '0']
- [blocks_throttle2_12, '0', qtgui_time_sink_x_21, '0']
- [blocks_throttle2_19, '0', qtgui_freq_sink_x_20, '3']
- [blocks_unpack_k_bits_bb_7, '0', blocks_char_to_float_8, '0']
- [digital_constellation_modulator_18, '0', blocks_throttle2_19, '0']
- [fir_filter_xxx_15, '0', analog_frequency_modulator_fc_16, '0']
- [fir_filter_xxx_15, '0', qtgui_time_sink_x_21, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
