options:
  parameters:
    author: Claude (Oct 2026), in the style of the learnSDR lessons
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: lesson31_Chirp_FMCW_Radar
    output_language: python
    title: Chirps and FMCW radar (simulation)
  states: {}

blocks:
- name: c
  id: variable
  parameters:
    comment: speed of light, m/s
    value: 3e8
  states: {}
- name: chirp_bandwidth
  id: variable
  parameters:
    comment: the chirp sweeps this far in frequency ...
    value: samp_rate*0.8
  states: {}
- name: chirp_period
  id: variable
  parameters:
    comment: ... in this much time (seconds)
    value: '1e-3'
  states: {}
- name: chirp_rate
  id: variable
  parameters:
    comment: Hz per second
    value: chirp_bandwidth/chirp_period
  states: {}
- name: echo_amplitude
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.3'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: target_range
  id: variable_qtgui_range
  parameters:
    comment: |-
      distance to the target in metres. The echo is
      delayed by 2*range/c; at 1 MS/s one sample is 150 m
      of range, which is why this "radar" only sees things
      tens of km away. A 50 MHz chirp would see 1.5 m.
    start: '0'
    step: '100'
    stop: 100e3
    value: 30e3
  states: {}
- name: analog_sig_source_x_10
  id: analog_sig_source_x
  parameters:
    amp: chirp_bandwidth
    comment: |-
      instantaneous frequency: a sawtooth from
      -B/2 to +B/2 once per chirp period
    freq: 1/chirp_period
    offset: '-chirp_bandwidth/2'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_delay_14
  id: blocks_delay
  parameters:
    comment: 'round trip: 2*range/c seconds'
    delay: int(2*target_range/c*samp_rate)
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_17
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: |-
      "de-chirp": transmitted x conj(received).
      The product of two chirps offset in time is a
      constant tone at f_beat = chirp_rate * delay
  states: {}
- name: blocks_multiply_const_vxx_15
  id: blocks_multiply_const_vxx
  parameters:
    const: echo_amplitude
    type: complex
  states: {}
- name: blocks_throttle2_12
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vco_c_11
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    comment: |-
      frequency -> complex sinusoid at that frequency:
      this is the chirp (Lesson 24 used the same block for FSK)
    samp_rate: samp_rate
    sensitivity: 2*math.pi
  states: {}
- name: channels_channel_model_16
  id: channels_channel_model
  parameters:
    comment: receiver noise
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: '[1.0]'
  states: {}
- name: import_6
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_18
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: |-
      range = f_beat * c / (2 * chirp_rate)
      with the defaults: 30 km -> 160 kHz
    fc: '0'
    fftsize: '4096'
    label1: beat tone
    name: '"De-chirped: beat frequency = chirp_rate x round-trip delay"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_13
  id: qtgui_time_sink_x
  parameters:
    label1: transmitted re
    label2: transmitted im
    name: '"Chirp"'
    size: '2048'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_19
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: the sawtooth frequency sweep is visible here
    fc: '0'
    fftsize: '1024'
    label1: received
    name: '"Received chirp"'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_10, '0', blocks_vco_c_11, '0']
- [blocks_delay_14, '0', blocks_multiply_const_vxx_15, '0']
- [blocks_multiply_conjugate_cc_17, '0', qtgui_freq_sink_x_18, '0']
- [blocks_multiply_const_vxx_15, '0', channels_channel_model_16, '0']
- [blocks_throttle2_12, '0', blocks_delay_14, '0']
- [blocks_throttle2_12, '0', blocks_multiply_conjugate_cc_17, '0']
- [blocks_throttle2_12, '0', qtgui_time_sink_x_13, '0']
- [blocks_vco_c_11, '0', blocks_throttle2_12, '0']
- [channels_channel_model_16, '0', blocks_multiply_conjugate_cc_17, '1']
- [channels_channel_model_16, '0', qtgui_waterfall_sink_x_19, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
